/* !Encoding: 65001  */
includes
{
  #include "__DiagLibrary.cin"
  #include "__cDiagService.cin"
  #include "__VariablesLib.cin"
  #include "__CaplGeneratorLib.cin"
  #include "__CANoeReportFuntionsLib.cin"
}

variables
{
  // Global variables defined within this CAPL file
  int64 __tt16cnt1;
  message `FDCAN2::`DIAGNOSTIC_RESPONSE_PAM __tt16msg0;
  int64 __tt16cnt3;
  message `FDCAN2::`DIAGNOSTIC_RESPONSE_PAM __tt16msg2;
  int64 __tt16cnt5;
  int64 __tt16cnt7;
  int64 __tt16cnt9;
  int64 __tt16cnt11;
  int64 __tt16cnt13;
  int64 __tt16cnt15;
  int64 __tt16cnt17;
  int64 __tt16cnt19;
  int64 __tt16cnt21;
  int64 __tt16cnt23;
  int64 __tt16cnt25;
  int64 __tt16cnt27;
  message `FDCAN2::`DIAGNOSTIC_RESPONSE_PAM __tt16msg26;
  int64 __tt16cnt29;
  message `FDCAN2::`DIAGNOSTIC_RESPONSE_PAM __tt16msg28;
  int64 __tt16cnt31;
  message `FDCAN2::`DIAGNOSTIC_RESPONSE_PAM __tt16msg30;
  int64 __tt16cnt33;
  int64 __tt16cnt35;
  int64 __tt16cnt37;
  int64 __tt16cnt39;
  int64 __tt16cnt41;
  int64 __tt16cnt43;
  int64 __tt16cnt45;
  int64 __tt16cnt47;
  int64 __tt16cnt49;
  int64 __tt16cnt51;
}

void Ttvee286j_HMI_General_Precondition()
{
  TestCommandBegin(__eWait, __cWait, "", "0");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Set_voltage", __eTestFct);
    AddIFParameterInt(syspar::`Power_Control::`RS_232_Port_Number);
    AddIFParameterDouble(syspar::`Power_Control::`Normal_Voltage);
    CallInterfaceFunction("Set_voltage (port=RS_232_Port_Number, volt=Normal_Voltage)", __cEmpty, "1");
  }


  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Reset_CAN", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "3");
  }


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (2500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "5");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 1;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "6");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 0;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (3 * 1000000000), 1000000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Reset_CAN", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "8");
  }


  TestCommandBegin(__eWait, __cWait, "", "9");
  {
    __Wait("1", (2500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "10");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 2;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "11");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "12");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_14::`TGW_CAMERA_DISP_STAT.phys = 4;
      __ReportSignalSetLValue("CAN signal 'TGW_CAMERA_DISP_STAT'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_14::`TGW_CAMERA_DISP_STAT, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 4, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "13");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "14");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 0;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "15");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "16");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`BRAKE_FD_2::`VehicleSpeedVSOSig.phys = 0;
      __ReportSignalSetLValue("CAN signal 'BCM::BRAKE_FD_2::VehicleSpeedVSOSig'", `FDCAN2::dbNode::`BCM::`BRAKE_FD_2::`VehicleSpeedVSOSig, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "17");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "18");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN14::dbNode::`BSM::`BRAKE_FD_2::`VehicleSpeedVSOSig.phys = 0;
      __ReportSignalSetLValue("CAN signal 'BSM::BRAKE_FD_2::VehicleSpeedVSOSig'", `FDCAN14::dbNode::`BSM::`BRAKE_FD_2::`VehicleSpeedVSOSig, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "19");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "20");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 1;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "21");
  {
    __Wait("1", (6000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

}

void Ttvee286j_General_Precondition_For_BootLoader()
{
  TestCommandBegin(__eWait, __cWait, "", "0");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Set_voltage", __eTestFct);
    AddIFParameterInt(syspar::`Power_Control::`RS_232_Port_Number);
    AddIFParameterDouble(syspar::`Power_Control::`Normal_Voltage);
    CallInterfaceFunction("Set_voltage (port=RS_232_Port_Number, volt=Normal_Voltage)", __cEmpty, "1");
  }


  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Reset_CAN", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "3");
  }


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (2500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("startTesterPresent", __eTestFct);
    CallInterfaceFunction("startTesterPresent ()", __cEmpty, "5");
  }


  TestCommandBegin(__eWait, __cWait, "", "9");
  {
    __Wait("1", (2500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "10");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        byte __tcLocVar0[1] = { 0x01 };
      
        __bArrayCtr = elCount(__tcLocVar0);
        memcpy(__bArray, __tcLocVar0, __bArrayCtr);
        __res = __DiagSetParameter(__req, "DiagSessionType", __bArray, __bArrayCtr);
        if(__res < 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'DiagSessionType'");
          break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar1[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar1, elCount(__tcLocVar1)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar1, elCount(__tcLocVar1), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "11");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("stopTesterPresent", __eTestFct);
    CallInterfaceFunction("stopTesterPresent ()", __cEmpty, "12");
  }


  TestCommandBegin(__eWait, __cWait, "", "13");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

}

void Ttvee286j_Default_Session_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 3;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x2, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x2;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x10, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x10;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0x1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      if (0 < 0 || 64 < 0)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 0);
        __nInt64 = 0;
      }
      if (1 < 0 || 64 < 1)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 1);
        __nInt64 = 0;
      }
      if (2 < 0 || 64 < 2)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 2);
        __nInt64 = 0;
      }
      if (3 < 0 || 64 < 3)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 3);
        __nInt64 = 0;
      }
      if (4 < 0 || 64 < 4)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 4);
        __nInt64 = 0;
      }
      if (5 < 0 || 64 < 5)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 5);
        __nInt64 = 0;
      }
      if (6 < 0 || 64 < 6)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 6);
        __nInt64 = 0;
      }
      __tt16cnt1 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback0", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt1 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        snprintf(__cArray, 2048, "%s", __cActual);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt1);
          snprintf(__cArray, 2048, "Last Received");
        }
        if (__tt16cnt1 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          byte __b0;
          byte __b1;
          byte __b2;
          byte __b3;
          byte __b4;
          byte __b5;
          byte __b6;
          __bVerdict = __eVerdictPass;
          __ReportTableHead5Columns(__cArray2, "Signal/Byte", __cTOp, __cRefVal, __cArray, __cRes);
        __b0 = __tt16msg0.byte((word)0);
        __csr = CheckSignalMatch(__b0, 0x6, "==") == 1;
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x6, "");
        __ReportCell(__b0);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b1 = __tt16msg0.byte((word)1);
        __csr = CheckSignalMatch(__b1, 0x50, "==") == 1;
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x50, "");
        __ReportCell(__b1);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b2 = __tt16msg0.byte((word)2);
        __csr = CheckSignalMatch(__b2, 0x1, "==") == 1;
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x1, "");
        __ReportCell(__b2);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b3 = __tt16msg0.byte((word)3);
        __csr = CheckSignalMatch(__b3, 0x0, "==") == 1;
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x0, "");
        __ReportCell(__b3);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b4 = __tt16msg0.byte((word)4);
        __csr = CheckSignalMatch(__b4, 0x32, "==") == 1;
        __ReportByteIndex(__cEmpty, 4, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x32, "");
        __ReportCell(__b4);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b5 = __tt16msg0.byte((word)5);
        __csr = CheckSignalMatch(__b5, 0x1, "==") == 1;
        __ReportByteIndex(__cEmpty, 5, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x1, "");
        __ReportCell(__b5);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b6 = __tt16msg0.byte((word)6);
        __csr = CheckSignalMatch(__b6, 0xF4, "==") == 1;
        __ReportByteIndex(__cEmpty, 6, __cArray);
        __ReportTableRow(0, __cArray, "==", 0xF4, "");
        __ReportCell(__b6);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
          __ReportTableEndVerdict("Resp1", __bVerdict);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback0(message * __m)
{
  dword __msg_callback_ret;
  byte __b0;
  byte __b1;
  byte __b2;
  byte __b3;
  byte __b4;
  byte __b5;
  byte __b6;
  if (__tt16cnt1 == -1)
  {
    return 1;
  }
  __tt16msg0 = __m;
  __msg_callback_ret = 1;
  __tt16cnt1++;
  if (0 < 0 || 64 < 0) return 0;
  __b0 = __tt16msg0.byte((word)0);
  __csr = CheckSignalMatch(__b0, 0x6, "==") == 1;
  __msg_callback_ret &= __csr;
  if (1 < 0 || 64 < 1) return 0;
  __b1 = __tt16msg0.byte((word)1);
  __csr = CheckSignalMatch(__b1, 0x50, "==") == 1;
  __msg_callback_ret &= __csr;
  if (2 < 0 || 64 < 2) return 0;
  __b2 = __tt16msg0.byte((word)2);
  __csr = CheckSignalMatch(__b2, 0x1, "==") == 1;
  __msg_callback_ret &= __csr;
  if (3 < 0 || 64 < 3) return 0;
  __b3 = __tt16msg0.byte((word)3);
  __csr = CheckSignalMatch(__b3, 0x0, "==") == 1;
  __msg_callback_ret &= __csr;
  if (4 < 0 || 64 < 4) return 0;
  __b4 = __tt16msg0.byte((word)4);
  __csr = CheckSignalMatch(__b4, 0x32, "==") == 1;
  __msg_callback_ret &= __csr;
  if (5 < 0 || 64 < 5) return 0;
  __b5 = __tt16msg0.byte((word)5);
  __csr = CheckSignalMatch(__b5, 0x1, "==") == 1;
  __msg_callback_ret &= __csr;
  if (6 < 0 || 64 < 6) return 0;
  __b6 = __tt16msg0.byte((word)6);
  __csr = CheckSignalMatch(__b6, 0xF4, "==") == 1;
  __msg_callback_ret &= __csr;
  if (__msg_callback_ret)
  {
    __tt16cnt1 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_Extended_Session_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 3;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x2, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x2;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x10, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x10;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      if (0 < 0 || 64 < 0)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 0);
        __nInt64 = 0;
      }
      if (1 < 0 || 64 < 1)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 1);
        __nInt64 = 0;
      }
      if (2 < 0 || 64 < 2)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 2);
        __nInt64 = 0;
      }
      if (3 < 0 || 64 < 3)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 3);
        __nInt64 = 0;
      }
      if (4 < 0 || 64 < 4)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 4);
        __nInt64 = 0;
      }
      if (5 < 0 || 64 < 5)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 5);
        __nInt64 = 0;
      }
      if (6 < 0 || 64 < 6)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 6);
        __nInt64 = 0;
      }
      __tt16cnt3 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback1", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt3 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        snprintf(__cArray, 2048, "%s", __cActual);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt3);
          snprintf(__cArray, 2048, "Last Received");
        }
        if (__tt16cnt3 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          byte __b0;
          byte __b1;
          byte __b2;
          byte __b3;
          byte __b4;
          byte __b5;
          byte __b6;
          __bVerdict = __eVerdictPass;
          __ReportTableHead5Columns(__cArray2, "Signal/Byte", __cTOp, __cRefVal, __cArray, __cRes);
        __b0 = __tt16msg2.byte((word)0);
        __csr = CheckSignalMatch(__b0, 0x6, "==") == 1;
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x6, "");
        __ReportCell(__b0);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b1 = __tt16msg2.byte((word)1);
        __csr = CheckSignalMatch(__b1, 0x50, "==") == 1;
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x50, "");
        __ReportCell(__b1);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b2 = __tt16msg2.byte((word)2);
        __csr = CheckSignalMatch(__b2, 0x3, "==") == 1;
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x3, "");
        __ReportCell(__b2);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b3 = __tt16msg2.byte((word)3);
        __csr = CheckSignalMatch(__b3, 0x0, "==") == 1;
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x0, "");
        __ReportCell(__b3);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b4 = __tt16msg2.byte((word)4);
        __csr = CheckSignalMatch(__b4, 0x32, "==") == 1;
        __ReportByteIndex(__cEmpty, 4, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x32, "");
        __ReportCell(__b4);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b5 = __tt16msg2.byte((word)5);
        __csr = CheckSignalMatch(__b5, 0x1, "==") == 1;
        __ReportByteIndex(__cEmpty, 5, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x1, "");
        __ReportCell(__b5);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b6 = __tt16msg2.byte((word)6);
        __csr = CheckSignalMatch(__b6, 0xF4, "==") == 1;
        __ReportByteIndex(__cEmpty, 6, __cArray);
        __ReportTableRow(0, __cArray, "==", 0xF4, "");
        __ReportCell(__b6);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
          __ReportTableEndVerdict("Resp1", __bVerdict);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback1(message * __m)
{
  dword __msg_callback_ret;
  byte __b0;
  byte __b1;
  byte __b2;
  byte __b3;
  byte __b4;
  byte __b5;
  byte __b6;
  if (__tt16cnt3 == -1)
  {
    return 1;
  }
  __tt16msg2 = __m;
  __msg_callback_ret = 1;
  __tt16cnt3++;
  if (0 < 0 || 64 < 0) return 0;
  __b0 = __tt16msg2.byte((word)0);
  __csr = CheckSignalMatch(__b0, 0x6, "==") == 1;
  __msg_callback_ret &= __csr;
  if (1 < 0 || 64 < 1) return 0;
  __b1 = __tt16msg2.byte((word)1);
  __csr = CheckSignalMatch(__b1, 0x50, "==") == 1;
  __msg_callback_ret &= __csr;
  if (2 < 0 || 64 < 2) return 0;
  __b2 = __tt16msg2.byte((word)2);
  __csr = CheckSignalMatch(__b2, 0x3, "==") == 1;
  __msg_callback_ret &= __csr;
  if (3 < 0 || 64 < 3) return 0;
  __b3 = __tt16msg2.byte((word)3);
  __csr = CheckSignalMatch(__b3, 0x0, "==") == 1;
  __msg_callback_ret &= __csr;
  if (4 < 0 || 64 < 4) return 0;
  __b4 = __tt16msg2.byte((word)4);
  __csr = CheckSignalMatch(__b4, 0x32, "==") == 1;
  __msg_callback_ret &= __csr;
  if (5 < 0 || 64 < 5) return 0;
  __b5 = __tt16msg2.byte((word)5);
  __csr = CheckSignalMatch(__b5, 0x1, "==") == 1;
  __msg_callback_ret &= __csr;
  if (6 < 0 || 64 < 6) return 0;
  __b6 = __tt16msg2.byte((word)6);
  __csr = CheckSignalMatch(__b6, 0xF4, "==") == 1;
  __msg_callback_ret &= __csr;
  if (__msg_callback_ret)
  {
    __tt16cnt3 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_Programming_Session_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 3;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x2, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x2;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x10, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x10;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x2, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0x2;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt5 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback2", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt5 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt5);
        }
        if (__tt16cnt5 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback2(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt5 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt5++;
  if (__msg_callback_ret)
  {
    __tt16cnt5 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F181_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F181_Application_Software_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Number_of_Application_SW_Logical_Blocks_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F181_App_SW_Identification::`Num_Application_SW_Logical_Blocks, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Number_of_Application_SW_Logical_Blocks_24\'", "==", syspar::`F181_App_SW_Identification::`Num_Application_SW_Logical_Blocks, "Num_Application_SW_Logical_Blocks");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Application_Software_Logical_Block_1_Version_Information__Year", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F181_App_SW_Identification::`APP_SW_Year, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Application_Software_Logical_Block_1_Version_Information__Year\'", "==", syspar::`F181_App_SW_Identification::`APP_SW_Year, "APP_SW_Year");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Application_Software_Logical_Block_1_Version_Information__Week", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F181_App_SW_Identification::`App_SW_Week, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Application_Software_Logical_Block_1_Version_Information__Week\'", "==", syspar::`F181_App_SW_Identification::`App_SW_Week, "App_SW_Week");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Application_Software_Logical_Block_1_Version_Information__Patc", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F181_App_SW_Identification::`App_SW_Patch, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Application_Software_Logical_Block_1_Version_Information__Patc\'", "==", syspar::`F181_App_SW_Identification::`App_SW_Patch, "App_SW_Patch");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Application_Software_Logical_Block_1_Version_Information__Iden", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F181_App_SW_Identification::`App_SW_Identification, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'_Application_Software_Logical_Block_1_Version_Information__Iden\'", "Bytes", __bArray, __bArrayCtr, "App_SW_Identification");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F181_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x81, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x81;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt7 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback3", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt7 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt7);
        }
        if (__tt16cnt7 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback3(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt7 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt7++;
  if (__msg_callback_ret)
  {
    __tt16cnt7 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F181_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F181_Application_Software_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Number_of_Application_SW_Logical_Blocks_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F181_App_SW_Identification::`Num_Application_SW_Logical_Blocks, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Number_of_Application_SW_Logical_Blocks_24\'", "==", syspar::`F181_App_SW_Identification::`Num_Application_SW_Logical_Blocks, "Num_Application_SW_Logical_Blocks");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Application_Software_Logical_Block_1_Version_Information__Year", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F181_App_SW_Identification::`APP_SW_Year, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Application_Software_Logical_Block_1_Version_Information__Year\'", "==", syspar::`F181_App_SW_Identification::`APP_SW_Year, "APP_SW_Year");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Application_Software_Logical_Block_1_Version_Information__Week", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F181_App_SW_Identification::`App_SW_Week, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Application_Software_Logical_Block_1_Version_Information__Week\'", "==", syspar::`F181_App_SW_Identification::`App_SW_Week, "App_SW_Week");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Application_Software_Logical_Block_1_Version_Information__Patc", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F181_App_SW_Identification::`App_SW_Patch, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Application_Software_Logical_Block_1_Version_Information__Patc\'", "==", syspar::`F181_App_SW_Identification::`App_SW_Patch, "App_SW_Patch");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Application_Software_Logical_Block_1_Version_Information__Iden", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F181_App_SW_Identification::`App_SW_Identification, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'_Application_Software_Logical_Block_1_Version_Information__Iden\'", "Bytes", __bArray, __bArrayCtr, "App_SW_Identification");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F182_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F182_Application_Data_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Number_of_Application_Data_Logical_Blocks_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F182_App_Data_Identification::`Num_App_Data_SW_Logical_Blocks, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Number_of_Application_Data_Logical_Blocks_24\'", "==", syspar::`F182_App_Data_Identification::`Num_App_Data_SW_Logical_Blocks, "Num_App_Data_SW_Logical_Blocks");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW_Year_32", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F182_App_Data_Identification::`App_Data_SW_Year, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW_Year_32\'", "==", syspar::`F182_App_Data_Identification::`App_Data_SW_Year, "App_Data_SW_Year");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Week_40", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F182_App_Data_Identification::`App_Data_SW_Week, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Week_40\'", "==", syspar::`F182_App_Data_Identification::`App_Data_SW_Week, "App_Data_SW_Week");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Patch_Level_48", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F182_App_Data_Identification::`App_Data_SW_Patch_Level, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Patch_Level_48\'", "==", syspar::`F182_App_Data_Identification::`App_Data_SW_Patch_Level, "App_Data_SW_Patch_Level");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_SW__Identification_56", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F182_App_Data_Identification::`App_Data_SW_Identification, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'_SW__Identification_56\'", "Bytes", __bArray, __bArrayCtr, "App_Data_SW_Identification");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F182_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F182_Application_Data_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Number_of_Application_Data_Logical_Blocks_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F182_App_Data_Identification::`Num_App_Data_SW_Logical_Blocks, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Number_of_Application_Data_Logical_Blocks_24\'", "==", syspar::`F182_App_Data_Identification::`Num_App_Data_SW_Logical_Blocks, "Num_App_Data_SW_Logical_Blocks");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW_Year_32", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F182_App_Data_Identification::`App_Data_SW_Year, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW_Year_32\'", "==", syspar::`F182_App_Data_Identification::`App_Data_SW_Year, "App_Data_SW_Year");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Week_40", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F182_App_Data_Identification::`App_Data_SW_Week, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Week_40\'", "==", syspar::`F182_App_Data_Identification::`App_Data_SW_Week, "App_Data_SW_Week");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Patch_Level_48", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F182_App_Data_Identification::`App_Data_SW_Patch_Level, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Patch_Level_48\'", "==", syspar::`F182_App_Data_Identification::`App_Data_SW_Patch_Level, "App_Data_SW_Patch_Level");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_SW__Identification_56", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F182_App_Data_Identification::`App_Data_SW_Identification, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'_SW__Identification_56\'", "Bytes", __bArray, __bArrayCtr, "App_Data_SW_Identification");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F182_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x82, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x82;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt9 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback4", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt9 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt9);
        }
        if (__tt16cnt9 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback4(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt9 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt9++;
  if (__msg_callback_ret)
  {
    __tt16cnt9 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F122_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F122_Software_EBOM_Part_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Software_Logical_Block_1_Part_Number_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_1_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Software_Logical_Block_1_Part_Number_24\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_1_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_2_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_2_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_2_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_2_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_3_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_3_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_3_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_3_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_4_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_4_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_4_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_4_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_5_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_5_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_5_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_5_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_6_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_6_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_6_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_6_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_7_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_7_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_7_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_7_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_8_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_8_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_8_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_8_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_9_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_9_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_9_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_9_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F122_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F122_Software_EBOM_Part_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Software_Logical_Block_1_Part_Number_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_1_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Software_Logical_Block_1_Part_Number_24\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_1_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_2_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_2_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_2_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_2_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_3_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_3_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_3_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_3_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_4_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_4_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_4_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_4_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_5_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_5_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_5_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_5_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_6_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_6_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_6_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_6_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_7_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_7_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_7_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_7_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_8_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_8_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_8_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_8_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Software_Logical_Block_9_Part_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F122_SW_EBOM_Part_Number::`SW_Loical_Block_9_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Software_Logical_Block_9_Part_Number\'", "Bytes", __bArray, __bArrayCtr, "SW_Loical_Block_9_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F122_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt11 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback5", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt11 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt11);
        }
        if (__tt16cnt11 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback5(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt11 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt11++;
  if (__msg_callback_ret)
  {
    __tt16cnt11 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F180_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F180_Boot_Software_Version_Information" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Number_of_Boot_Software_Logical_Blocks_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F180_Boot_SW_Version_Information::`Num_Boot_SW_Logical_Blocks, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Number_of_Boot_Software_Logical_Blocks_24\'", "==", syspar::`F180_Boot_SW_Version_Information::`Num_Boot_SW_Logical_Blocks, "Num_Boot_SW_Logical_Blocks");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW_Year_32", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F180_Boot_SW_Version_Information::`Software_Year, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW_Year_32\'", "==", syspar::`F180_Boot_SW_Version_Information::`Software_Year, "Software_Year");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Week_40", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F180_Boot_SW_Version_Information::`Software_Week, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Week_40\'", "==", syspar::`F180_Boot_SW_Version_Information::`Software_Week, "Software_Week");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Patch_Level_48", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F180_Boot_SW_Version_Information::`Software_Patch_Level, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Patch_Level_48\'", "==", syspar::`F180_Boot_SW_Version_Information::`Software_Patch_Level, "Software_Patch_Level");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_SW__Identification_56", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F180_Boot_SW_Version_Information::`Software_Identification, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'_SW__Identification_56\'", "Bytes", __bArray, __bArrayCtr, "Software_Identification");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F180_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F180_Boot_Software_Version_Information" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Number_of_Boot_Software_Logical_Blocks_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F180_Boot_SW_Version_Information::`Num_Boot_SW_Logical_Blocks, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Number_of_Boot_Software_Logical_Blocks_24\'", "==", syspar::`F180_Boot_SW_Version_Information::`Num_Boot_SW_Logical_Blocks, "Num_Boot_SW_Logical_Blocks");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW_Year_32", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F180_Boot_SW_Version_Information::`Software_Year, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW_Year_32\'", "==", syspar::`F180_Boot_SW_Version_Information::`Software_Year, "Software_Year");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Week_40", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F180_Boot_SW_Version_Information::`Software_Week, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Week_40\'", "==", syspar::`F180_Boot_SW_Version_Information::`Software_Week, "Software_Week");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Patch_Level_48", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F180_Boot_SW_Version_Information::`Software_Patch_Level, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Patch_Level_48\'", "==", syspar::`F180_Boot_SW_Version_Information::`Software_Patch_Level, "Software_Patch_Level");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_SW__Identification_56", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F180_Boot_SW_Version_Information::`Software_Identification, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'_SW__Identification_56\'", "Bytes", __bArray, __bArrayCtr, "Software_Identification");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F180_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x80, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x80;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt13 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback6", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt13 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt13);
        }
        if (__tt16cnt13 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback6(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt13 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt13++;
  if (__msg_callback_ret)
  {
    __tt16cnt13 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F132_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F132_EBOM_ECU_Part_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_EBOM_ECU_Part_Number_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F132_EBOM_ECU_Part_Number::`EBOM_ECU_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_EBOM_ECU_Part_Number_24\'", "Bytes", __bArray, __bArrayCtr, "EBOM_ECU_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F132_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F132_EBOM_ECU_Part_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_EBOM_ECU_Part_Number_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F132_EBOM_ECU_Part_Number::`EBOM_ECU_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_EBOM_ECU_Part_Number_24\'", "Bytes", __bArray, __bArrayCtr, "EBOM_ECU_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F132_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x32, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x32;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt15 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback7", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt15 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt15);
        }
        if (__tt16cnt15 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback7(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt15 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt15++;
  if (__msg_callback_ret)
  {
    __tt16cnt15 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F1A2_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F1A2_Vector_Delivery_ID" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Vector_Release_Version_Basic_Software_BSW_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F1A2_Vector_Delivery_ID::`Vector_Release_Version_BSW, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Vector_Release_Version_Basic_Software_BSW_24\'", "Bytes", __bArray, __bArrayCtr, "Vector_Release_Version_BSW");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Vector_License_Number_CBD_Number_48", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F1A2_Vector_Delivery_ID::`Vector_License_Number_CBD_Num, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Vector_License_Number_CBD_Number_48\'", "Bytes", __bArray, __bArrayCtr, "Vector_License_Number_CBD_Num");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Vector_Delivery_Number_80", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F1A2_Vector_Delivery_ID::`Vector_Delivery_Number, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Vector_Delivery_Number_80\'", "==", syspar::`F1A2_Vector_Delivery_ID::`Vector_Delivery_Number, "Vector_Delivery_Number");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Autosar_Revision_ASR_Major_Release_88", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F1A2_Vector_Delivery_ID::`Autosar_Revision_ASR_Major_Release, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Autosar_Revision_ASR_Major_Release_88\'", "==", syspar::`F1A2_Vector_Delivery_ID::`Autosar_Revision_ASR_Major_Release, "Autosar_Revision_ASR_Major_Release");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Software_License_Package_SLP_96", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F1A2_Vector_Delivery_ID::`Software_License_Package_SLP, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Software_License_Package_SLP_96\'", "==", syspar::`F1A2_Vector_Delivery_ID::`Software_License_Package_SLP, "Software_License_Package_SLP");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F1A2_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F1A2_Vector_Delivery_ID" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Vector_Release_Version_Basic_Software_BSW_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F1A2_Vector_Delivery_ID::`Vector_Release_Version_BSW, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Vector_Release_Version_Basic_Software_BSW_24\'", "Bytes", __bArray, __bArrayCtr, "Vector_Release_Version_BSW");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Vector_License_Number_CBD_Number_48", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F1A2_Vector_Delivery_ID::`Vector_License_Number_CBD_Num, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Vector_License_Number_CBD_Number_48\'", "Bytes", __bArray, __bArrayCtr, "Vector_License_Number_CBD_Num");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Vector_Delivery_Number_80", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F1A2_Vector_Delivery_ID::`Vector_Delivery_Number, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Vector_Delivery_Number_80\'", "==", syspar::`F1A2_Vector_Delivery_ID::`Vector_Delivery_Number, "Vector_Delivery_Number");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Autosar_Revision_ASR_Major_Release_88", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F1A2_Vector_Delivery_ID::`Autosar_Revision_ASR_Major_Release, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Autosar_Revision_ASR_Major_Release_88\'", "==", syspar::`F1A2_Vector_Delivery_ID::`Autosar_Revision_ASR_Major_Release, "Autosar_Revision_ASR_Major_Release");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Software_License_Package_SLP_96", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F1A2_Vector_Delivery_ID::`Software_License_Package_SLP, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Software_License_Package_SLP_96\'", "==", syspar::`F1A2_Vector_Delivery_ID::`Software_License_Package_SLP, "Software_License_Package_SLP");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F1A2_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xA2, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0xA2;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt17 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback8", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt17 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt17);
        }
        if (__tt16cnt17 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback8(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt17 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt17++;
  if (__msg_callback_ret)
  {
    __tt16cnt17 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F154_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F154_Hardware_Supplier_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Hardware_Supplier_Identification_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F154_HW_Supplier_Identification::`Hardware_Supplier_Identification, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Hardware_Supplier_Identification_24\'", "Bytes", __bArray, __bArrayCtr, "Hardware_Supplier_Identification");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F154_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F154_Hardware_Supplier_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Hardware_Supplier_Identification_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F154_HW_Supplier_Identification::`Hardware_Supplier_Identification, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Hardware_Supplier_Identification_24\'", "Bytes", __bArray, __bArrayCtr, "Hardware_Supplier_Identification");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F154_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
      snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
      __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
      __ReportByteIndex(__cEmpty, 0, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
      
      if (0 >= 0 && 0 < 64)
      {
        __output.byte((word)0) = 0x3;
      
      }
      else
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
        __testStepInitOk = 0;
      }
      __ReportByteIndex(__cEmpty, 1, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
      
      if (1 >= 0 && 1 < 64)
      {
        __output.byte((word)1) = 0x22;
      
      }
      else
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
        __testStepInitOk = 0;
      }
      __ReportByteIndex(__cEmpty, 2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
      
      if (2 >= 0 && 2 < 64)
      {
        __output.byte((word)2) = 0xF1;
      
      }
      else
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
        __testStepInitOk = 0;
      }
      __ReportByteIndex(__cEmpty, 3, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0x54, "");
      
      if (3 >= 0 && 3 < 64)
      {
        __output.byte((word)3) = 0x54;
      
      }
      else
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
        __testStepInitOk = 0;
      }
    
      __ReportTableEndTestStep("Req1");
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt19 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback9", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt19 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt19);
        }
        if (__tt16cnt19 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback9(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt19 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt19++;
  if (__msg_callback_ret)
  {
    __tt16cnt19 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F155_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F155_Software_Supplier_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Software_Supplier_Identification_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F155_SW_Supplier_Identification::`Software_Supplier_Identification, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Software_Supplier_Identification_24\'", "Bytes", __bArray, __bArrayCtr, "Software_Supplier_Identification");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F155_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F155_Software_Supplier_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Software_Supplier_Identification_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F155_SW_Supplier_Identification::`Software_Supplier_Identification, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Software_Supplier_Identification_24\'", "Bytes", __bArray, __bArrayCtr, "Software_Supplier_Identification");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F155_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x55, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x55;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt21 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback10", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt21 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt21);
        }
        if (__tt16cnt21 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback10(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt21 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt21++;
  if (__msg_callback_ret)
  {
    __tt16cnt21 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F187_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F187_CODEP_ECU_Part_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_CODEP_ECU_Part_Number_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F187_CODEP_ECU_Part_Number::`CODEP_ECU_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_CODEP_ECU_Part_Number_24\'", "Bytes", __bArray, __bArrayCtr, "CODEP_ECU_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F187_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F187_CODEP_ECU_Part_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_CODEP_ECU_Part_Number_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F187_CODEP_ECU_Part_Number::`CODEP_ECU_Part_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_CODEP_ECU_Part_Number_24\'", "Bytes", __bArray, __bArrayCtr, "CODEP_ECU_Part_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F187_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x87, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x87;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt23 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback11", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt23 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt23);
        }
        if (__tt16cnt23 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback11(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt23 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt23++;
  if (__msg_callback_ret)
  {
    __tt16cnt23 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F110_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F110_ECU_Diagnostic_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Diagnostic_Variant_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F110_ECU_Diagnostic_Identification::`Diagnostic_Variant, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Diagnostic_Variant_24\'", "Bytes", __bArray, __bArrayCtr, "Diagnostic_Variant");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Diagnostic_Version_40", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F110_ECU_Diagnostic_Identification::`Diagnostic_Version, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Diagnostic_Version_40\'", "Bytes", __bArray, __bArrayCtr, "Diagnostic_Version");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Flash_Definition_Number_FDN_72", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F110_ECU_Diagnostic_Identification::`Flash_Definition_Number_FDN, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Flash_Definition_Number_FDN_72\'", "Bytes", __bArray, __bArrayCtr, "Flash_Definition_Number_FDN");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Supplier_ID_88", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F110_ECU_Diagnostic_Identification::`Supplier_ID, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Supplier_ID_88\'", "Bytes", __bArray, __bArrayCtr, "Supplier_ID");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F110_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F110_ECU_Diagnostic_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Diagnostic_Variant_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F110_ECU_Diagnostic_Identification::`Diagnostic_Variant, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Diagnostic_Variant_24\'", "Bytes", __bArray, __bArrayCtr, "Diagnostic_Variant");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Diagnostic_Version_40", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F110_ECU_Diagnostic_Identification::`Diagnostic_Version, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Diagnostic_Version_40\'", "Bytes", __bArray, __bArrayCtr, "Diagnostic_Version");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Flash_Definition_Number_FDN_72", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F110_ECU_Diagnostic_Identification::`Flash_Definition_Number_FDN, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Flash_Definition_Number_FDN_72\'", "Bytes", __bArray, __bArrayCtr, "Flash_Definition_Number_FDN");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Supplier_ID_88", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F110_ECU_Diagnostic_Identification::`Supplier_ID, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Supplier_ID_88\'", "Bytes", __bArray, __bArrayCtr, "Supplier_ID");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F110_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 8;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x10, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x10;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt25 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback12", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt25 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt25);
        }
        if (__tt16cnt25 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback12(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt25 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt25++;
  if (__msg_callback_ret)
  {
    __tt16cnt25 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F186_Active_Diagnostic_Session::`Default_Session, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", syspar::`F186_Active_Diagnostic_Session::`Default_Session, "Default_Session");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F186_Active_Diagnostic_Session::`Application_Mode, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "Bytes", __bArray, __bArrayCtr, "Application_Mode");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F186_DID_with_Standard_Physical_Address_Default_Session()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 8;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x86, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x86;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      if (0 < 0 || 64 < 0)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 0);
        __nInt64 = 0;
      }
      if (1 < 0 || 64 < 1)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 1);
        __nInt64 = 0;
      }
      if (2 < 0 || 64 < 2)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 2);
        __nInt64 = 0;
      }
      if (3 < 0 || 64 < 3)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 3);
        __nInt64 = 0;
      }
      if (4 < 0 || 64 < 4)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 4);
        __nInt64 = 0;
      }
      if (5 < 0 || 64 < 5)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 5);
        __nInt64 = 0;
      }
      if (6 < 0 || 64 < 6)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 6);
        __nInt64 = 0;
      }
      __tt16cnt27 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback13", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt27 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        snprintf(__cArray, 2048, "%s", __cActual);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt27);
          snprintf(__cArray, 2048, "Last Received");
        }
        if (__tt16cnt27 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          byte __b0;
          byte __b1;
          byte __b2;
          byte __b3;
          byte __b4;
          byte __b5;
          byte __b6;
          __bVerdict = __eVerdictPass;
          __ReportTableHead5Columns(__cArray2, "Signal/Byte", __cTOp, __cRefVal, __cArray, __cRes);
        __b0 = __tt16msg26.byte((word)0);
        __csr = CheckSignalMatch(__b0, 0x6, "==") == 1;
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x6, "");
        __ReportCell(__b0);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b1 = __tt16msg26.byte((word)1);
        __csr = CheckSignalMatch(__b1, 0x62, "==") == 1;
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x62, "");
        __ReportCell(__b1);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b2 = __tt16msg26.byte((word)2);
        __csr = CheckSignalMatch(__b2, 0xF1, "==") == 1;
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, "==", 0xF1, "");
        __ReportCell(__b2);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b3 = __tt16msg26.byte((word)3);
        __csr = CheckSignalMatch(__b3, 0x86, "==") == 1;
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x86, "");
        __ReportCell(__b3);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b4 = __tt16msg26.byte((word)4);
        __csr = CheckSignalMatch(__b4, 0x1, "==") == 1;
        __ReportByteIndex(__cEmpty, 4, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x1, "");
        __ReportCell(__b4);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b5 = __tt16msg26.byte((word)5);
        __csr = CheckSignalMatch(__b5, 0x5, "==") == 1;
        __ReportByteIndex(__cEmpty, 5, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x5, "");
        __ReportCell(__b5);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b6 = __tt16msg26.byte((word)6);
        __csr = CheckSignalMatch(__b6, 0x0, "==") == 1;
        __ReportByteIndex(__cEmpty, 6, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x0, "");
        __ReportCell(__b6);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
          __ReportTableEndVerdict("Resp1", __bVerdict);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback13(message * __m)
{
  dword __msg_callback_ret;
  byte __b0;
  byte __b1;
  byte __b2;
  byte __b3;
  byte __b4;
  byte __b5;
  byte __b6;
  if (__tt16cnt27 == -1)
  {
    return 1;
  }
  __tt16msg26 = __m;
  __msg_callback_ret = 1;
  __tt16cnt27++;
  if (0 < 0 || 64 < 0) return 0;
  __b0 = __tt16msg26.byte((word)0);
  __csr = CheckSignalMatch(__b0, 0x6, "==") == 1;
  __msg_callback_ret &= __csr;
  if (1 < 0 || 64 < 1) return 0;
  __b1 = __tt16msg26.byte((word)1);
  __csr = CheckSignalMatch(__b1, 0x62, "==") == 1;
  __msg_callback_ret &= __csr;
  if (2 < 0 || 64 < 2) return 0;
  __b2 = __tt16msg26.byte((word)2);
  __csr = CheckSignalMatch(__b2, 0xF1, "==") == 1;
  __msg_callback_ret &= __csr;
  if (3 < 0 || 64 < 3) return 0;
  __b3 = __tt16msg26.byte((word)3);
  __csr = CheckSignalMatch(__b3, 0x86, "==") == 1;
  __msg_callback_ret &= __csr;
  if (4 < 0 || 64 < 4) return 0;
  __b4 = __tt16msg26.byte((word)4);
  __csr = CheckSignalMatch(__b4, 0x1, "==") == 1;
  __msg_callback_ret &= __csr;
  if (5 < 0 || 64 < 5) return 0;
  __b5 = __tt16msg26.byte((word)5);
  __csr = CheckSignalMatch(__b5, 0x5, "==") == 1;
  __msg_callback_ret &= __csr;
  if (6 < 0 || 64 < 6) return 0;
  __b6 = __tt16msg26.byte((word)6);
  __csr = CheckSignalMatch(__b6, 0x0, "==") == 1;
  __msg_callback_ret &= __csr;
  if (__msg_callback_ret)
  {
    __tt16cnt27 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F186_DID_with_PhysicalAdd_ExtendedSession()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F186_Active_Diagnostic_Session::`Extended_Session, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", syspar::`F186_Active_Diagnostic_Session::`Extended_Session, "Extended_Session");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F186_Active_Diagnostic_Session::`Application_Mode, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "Bytes", __bArray, __bArrayCtr, "Application_Mode");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F186_DID_with_Standard_Physical_Address_Extended_Session()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 8;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x86, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x86;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      if (0 < 0 || 64 < 0)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 0);
        __nInt64 = 0;
      }
      if (1 < 0 || 64 < 1)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 1);
        __nInt64 = 0;
      }
      if (2 < 0 || 64 < 2)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 2);
        __nInt64 = 0;
      }
      if (3 < 0 || 64 < 3)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 3);
        __nInt64 = 0;
      }
      if (4 < 0 || 64 < 4)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 4);
        __nInt64 = 0;
      }
      if (5 < 0 || 64 < 5)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 5);
        __nInt64 = 0;
      }
      if (6 < 0 || 64 < 6)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 6);
        __nInt64 = 0;
      }
      __tt16cnt29 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback14", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt29 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        snprintf(__cArray, 2048, "%s", __cActual);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt29);
          snprintf(__cArray, 2048, "Last Received");
        }
        if (__tt16cnt29 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          byte __b0;
          byte __b1;
          byte __b2;
          byte __b3;
          byte __b4;
          byte __b5;
          byte __b6;
          __bVerdict = __eVerdictPass;
          __ReportTableHead5Columns(__cArray2, "Signal/Byte", __cTOp, __cRefVal, __cArray, __cRes);
        __b0 = __tt16msg28.byte((word)0);
        __csr = CheckSignalMatch(__b0, 0x6, "==") == 1;
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x6, "");
        __ReportCell(__b0);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b1 = __tt16msg28.byte((word)1);
        __csr = CheckSignalMatch(__b1, 0x62, "==") == 1;
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x62, "");
        __ReportCell(__b1);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b2 = __tt16msg28.byte((word)2);
        __csr = CheckSignalMatch(__b2, 0xF1, "==") == 1;
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, "==", 0xF1, "");
        __ReportCell(__b2);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b3 = __tt16msg28.byte((word)3);
        __csr = CheckSignalMatch(__b3, 0x86, "==") == 1;
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x86, "");
        __ReportCell(__b3);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b4 = __tt16msg28.byte((word)4);
        __csr = CheckSignalMatch(__b4, 0x3, "==") == 1;
        __ReportByteIndex(__cEmpty, 4, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x3, "");
        __ReportCell(__b4);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b5 = __tt16msg28.byte((word)5);
        __csr = CheckSignalMatch(__b5, 0x5, "==") == 1;
        __ReportByteIndex(__cEmpty, 5, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x5, "");
        __ReportCell(__b5);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b6 = __tt16msg28.byte((word)6);
        __csr = CheckSignalMatch(__b6, 0x0, "==") == 1;
        __ReportByteIndex(__cEmpty, 6, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x0, "");
        __ReportCell(__b6);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
          __ReportTableEndVerdict("Resp1", __bVerdict);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback14(message * __m)
{
  dword __msg_callback_ret;
  byte __b0;
  byte __b1;
  byte __b2;
  byte __b3;
  byte __b4;
  byte __b5;
  byte __b6;
  if (__tt16cnt29 == -1)
  {
    return 1;
  }
  __tt16msg28 = __m;
  __msg_callback_ret = 1;
  __tt16cnt29++;
  if (0 < 0 || 64 < 0) return 0;
  __b0 = __tt16msg28.byte((word)0);
  __csr = CheckSignalMatch(__b0, 0x6, "==") == 1;
  __msg_callback_ret &= __csr;
  if (1 < 0 || 64 < 1) return 0;
  __b1 = __tt16msg28.byte((word)1);
  __csr = CheckSignalMatch(__b1, 0x62, "==") == 1;
  __msg_callback_ret &= __csr;
  if (2 < 0 || 64 < 2) return 0;
  __b2 = __tt16msg28.byte((word)2);
  __csr = CheckSignalMatch(__b2, 0xF1, "==") == 1;
  __msg_callback_ret &= __csr;
  if (3 < 0 || 64 < 3) return 0;
  __b3 = __tt16msg28.byte((word)3);
  __csr = CheckSignalMatch(__b3, 0x86, "==") == 1;
  __msg_callback_ret &= __csr;
  if (4 < 0 || 64 < 4) return 0;
  __b4 = __tt16msg28.byte((word)4);
  __csr = CheckSignalMatch(__b4, 0x3, "==") == 1;
  __msg_callback_ret &= __csr;
  if (5 < 0 || 64 < 5) return 0;
  __b5 = __tt16msg28.byte((word)5);
  __csr = CheckSignalMatch(__b5, 0x5, "==") == 1;
  __msg_callback_ret &= __csr;
  if (6 < 0 || 64 < 6) return 0;
  __b6 = __tt16msg28.byte((word)6);
  __csr = CheckSignalMatch(__b6, 0x0, "==") == 1;
  __msg_callback_ret &= __csr;
  if (__msg_callback_ret)
  {
    __tt16cnt29 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F186_DID_with_PhysicalAdd_ProgrammingSession()
{
  TestCommandBegin(__eWait, __cWait, "", "0");
  {
    __Wait("1", (1100 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F186_Active_Diagnostic_Session::`Programming_Session, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", syspar::`F186_Active_Diagnostic_Session::`Programming_Session, "Programming_Session");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F186_Active_Diagnostic_Session::`Bootloader_Mode, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "Bytes", __bArray, __bArrayCtr, "Bootloader_Mode");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F186_DID_with_Standard_Physical_Address_Programming_Session()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 8;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x86, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x86;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      if (0 < 0 || 64 < 0)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 0);
        __nInt64 = 0;
      }
      if (1 < 0 || 64 < 1)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 1);
        __nInt64 = 0;
      }
      if (2 < 0 || 64 < 2)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 2);
        __nInt64 = 0;
      }
      if (3 < 0 || 64 < 3)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 3);
        __nInt64 = 0;
      }
      if (4 < 0 || 64 < 4)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 4);
        __nInt64 = 0;
      }
      if (5 < 0 || 64 < 5)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 5);
        __nInt64 = 0;
      }
      if (6 < 0 || 64 < 6)
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to get byte %I64d in message.", (int64) 6);
        __nInt64 = 0;
      }
      __tt16cnt31 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback15", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt31 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        snprintf(__cArray, 2048, "%s", __cActual);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt31);
          snprintf(__cArray, 2048, "Last Received");
        }
        if (__tt16cnt31 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          byte __b0;
          byte __b1;
          byte __b2;
          byte __b3;
          byte __b4;
          byte __b5;
          byte __b6;
          __bVerdict = __eVerdictPass;
          __ReportTableHead5Columns(__cArray2, "Signal/Byte", __cTOp, __cRefVal, __cArray, __cRes);
        __b0 = __tt16msg30.byte((word)0);
        __csr = CheckSignalMatch(__b0, 0x6, "==") == 1;
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x6, "");
        __ReportCell(__b0);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b1 = __tt16msg30.byte((word)1);
        __csr = CheckSignalMatch(__b1, 0x62, "==") == 1;
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x62, "");
        __ReportCell(__b1);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b2 = __tt16msg30.byte((word)2);
        __csr = CheckSignalMatch(__b2, 0xF1, "==") == 1;
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, "==", 0xF1, "");
        __ReportCell(__b2);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b3 = __tt16msg30.byte((word)3);
        __csr = CheckSignalMatch(__b3, 0x86, "==") == 1;
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x86, "");
        __ReportCell(__b3);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b4 = __tt16msg30.byte((word)4);
        __csr = CheckSignalMatch(__b4, 0x2, "==") == 1;
        __ReportByteIndex(__cEmpty, 4, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x2, "");
        __ReportCell(__b4);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b5 = __tt16msg30.byte((word)5);
        __csr = CheckSignalMatch(__b5, 0x5, "==") == 1;
        __ReportByteIndex(__cEmpty, 5, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x5, "");
        __ReportCell(__b5);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
        __b6 = __tt16msg30.byte((word)6);
        __csr = CheckSignalMatch(__b6, 0x0, "==") == 1;
        __ReportByteIndex(__cEmpty, 6, __cArray);
        __ReportTableRow(0, __cArray, "==", 0x0, "");
        __ReportCell(__b6);
        __ReportCellResult(__csr, __ePassFail);
          __bVerdict &= __csr;
          __ReportTableEndVerdict("Resp1", __bVerdict);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback15(message * __m)
{
  dword __msg_callback_ret;
  byte __b0;
  byte __b1;
  byte __b2;
  byte __b3;
  byte __b4;
  byte __b5;
  byte __b6;
  if (__tt16cnt31 == -1)
  {
    return 1;
  }
  __tt16msg30 = __m;
  __msg_callback_ret = 1;
  __tt16cnt31++;
  if (0 < 0 || 64 < 0) return 0;
  __b0 = __tt16msg30.byte((word)0);
  __csr = CheckSignalMatch(__b0, 0x6, "==") == 1;
  __msg_callback_ret &= __csr;
  if (1 < 0 || 64 < 1) return 0;
  __b1 = __tt16msg30.byte((word)1);
  __csr = CheckSignalMatch(__b1, 0x62, "==") == 1;
  __msg_callback_ret &= __csr;
  if (2 < 0 || 64 < 2) return 0;
  __b2 = __tt16msg30.byte((word)2);
  __csr = CheckSignalMatch(__b2, 0xF1, "==") == 1;
  __msg_callback_ret &= __csr;
  if (3 < 0 || 64 < 3) return 0;
  __b3 = __tt16msg30.byte((word)3);
  __csr = CheckSignalMatch(__b3, 0x86, "==") == 1;
  __msg_callback_ret &= __csr;
  if (4 < 0 || 64 < 4) return 0;
  __b4 = __tt16msg30.byte((word)4);
  __csr = CheckSignalMatch(__b4, 0x2, "==") == 1;
  __msg_callback_ret &= __csr;
  if (5 < 0 || 64 < 5) return 0;
  __b5 = __tt16msg30.byte((word)5);
  __csr = CheckSignalMatch(__b5, 0x5, "==") == 1;
  __msg_callback_ret &= __csr;
  if (6 < 0 || 64 < 6) return 0;
  __b6 = __tt16msg30.byte((word)6);
  __csr = CheckSignalMatch(__b6, 0x0, "==") == 1;
  __msg_callback_ret &= __csr;
  if (__msg_callback_ret)
  {
    __tt16cnt31 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F186_DID_with_FunctionalAdd_DefaultSession()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F186_Active_Diagnostic_Session::`Default_Session, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", syspar::`F186_Active_Diagnostic_Session::`Default_Session, "Default_Session");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F186_Active_Diagnostic_Session::`Application_Mode, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "Bytes", __bArray, __bArrayCtr, "Application_Mode");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F186_DID_with_FunctionalAdd_ExtendedSession()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F186_Active_Diagnostic_Session::`Extended_Session, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", syspar::`F186_Active_Diagnostic_Session::`Extended_Session, "Extended_Session");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F186_Active_Diagnostic_Session::`Application_Mode, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "Bytes", __bArray, __bArrayCtr, "Application_Mode");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F186_DID_with_FunctionalAdd_ProgrammingSession()
{
  TestCommandBegin(__eWait, __cWait, "", "0");
  {
    __Wait("1", (1100 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`F186_Active_Diagnostic_Session::`Programming_Session, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", syspar::`F186_Active_Diagnostic_Session::`Programming_Session, "Programming_Session");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, syspar::`F186_Active_Diagnostic_Session::`Bootloader_Mode, elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "Bytes", __bArray, __bArrayCtr, "Bootloader_Mode");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F10D_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F10D_Diagnostic_Specification_Information" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Unified_Diagnostic_Services_UDS__Diagnostic_Protocol_Version_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F10D_Diagnostic_Specification_Information::`UDS_Diagnostic_Protocol_Version, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Unified_Diagnostic_Services_UDS__Diagnostic_Protocol_Version_24\'", "Bytes", __bArray, __bArrayCtr, "UDS_Diagnostic_Protocol_Version");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_ECU_Flash_Reprogramming_Requirements_Version_32", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F10D_Diagnostic_Specification_Information::`ECU_Flash_Reprogramming_Requirement_Version, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_ECU_Flash_Reprogramming_Requirements_Version_32\'", "Bytes", __bArray, __bArrayCtr, "ECU_Flash_Reprogramming_Requirement_Version");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Standard_Diagnostic_Data_UDS_Version_40", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F10D_Diagnostic_Specification_Information::`Standard_Diagnostic_Data_UDS_Version, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Standard_Diagnostic_Data_UDS_Version_40\'", "Bytes", __bArray, __bArrayCtr, "Standard_Diagnostic_Data_UDS_Version");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Diagnostic_Requirements_Standard_Version_48", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F10D_Diagnostic_Specification_Information::`Diagnostic_Requirement_Standard_Version, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Diagnostic_Requirements_Standard_Version_48\'", "Bytes", __bArray, __bArrayCtr, "Diagnostic_Requirement_Standard_Version");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F10D_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F10D_Diagnostic_Specification_Information" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Unified_Diagnostic_Services_UDS__Diagnostic_Protocol_Version_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F10D_Diagnostic_Specification_Information::`UDS_Diagnostic_Protocol_Version, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Unified_Diagnostic_Services_UDS__Diagnostic_Protocol_Version_24\'", "Bytes", __bArray, __bArrayCtr, "UDS_Diagnostic_Protocol_Version");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_ECU_Flash_Reprogramming_Requirements_Version_32", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F10D_Diagnostic_Specification_Information::`ECU_Flash_Reprogramming_Requirement_Version, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_ECU_Flash_Reprogramming_Requirements_Version_32\'", "Bytes", __bArray, __bArrayCtr, "ECU_Flash_Reprogramming_Requirement_Version");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Standard_Diagnostic_Data_UDS_Version_40", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F10D_Diagnostic_Specification_Information::`Standard_Diagnostic_Data_UDS_Version, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Standard_Diagnostic_Data_UDS_Version_40\'", "Bytes", __bArray, __bArrayCtr, "Standard_Diagnostic_Data_UDS_Version");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Diagnostic_Requirements_Standard_Version_48", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`F10D_Diagnostic_Specification_Information::`Diagnostic_Requirement_Standard_Version, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Diagnostic_Requirements_Standard_Version_48\'", "Bytes", __bArray, __bArrayCtr, "Diagnostic_Requirement_Standard_Version");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F10D_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
      snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
      __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
      __ReportByteIndex(__cEmpty, 0, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
      
      if (0 >= 0 && 0 < 64)
      {
        __output.byte((word)0) = 0x3;
      
      }
      else
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
        __testStepInitOk = 0;
      }
      __ReportByteIndex(__cEmpty, 1, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
      
      if (1 >= 0 && 1 < 64)
      {
        __output.byte((word)1) = 0x22;
      
      }
      else
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
        __testStepInitOk = 0;
      }
      __ReportByteIndex(__cEmpty, 2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
      
      if (2 >= 0 && 2 < 64)
      {
        __output.byte((word)2) = 0xF1;
      
      }
      else
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
        __testStepInitOk = 0;
      }
      __ReportByteIndex(__cEmpty, 3, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0xD, "");
      
      if (3 >= 0 && 3 < 64)
      {
        __output.byte((word)3) = 0xD;
      
      }
      else
      {
        testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
        __testStepInitOk = 0;
      }
    
      __ReportTableEndTestStep("Req1");
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt33 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback16", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt33 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt33);
        }
        if (__tt16cnt33 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback16(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt33 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt33++;
  if (__msg_callback_ret)
  {
    __tt16cnt33 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F112_DID_with_Physical_Addressing()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F112_PTESLM_Hardware_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "_Hardware_EBOM_Part_Number_24", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'_Hardware_EBOM_Part_Number_24\'", "==", "", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F112_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F112_PTESLM_Hardware_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Hardware_EBOM_Part_Number_24", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`DID_F112_Hardware_Number::`EBOM_Hardware_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Hardware_EBOM_Part_Number_24\'", "Bytes", __bArray, __bArrayCtr, "EBOM_Hardware_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F112_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x12, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x12;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt35 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback17", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt35 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt35);
        }
        if (__tt16cnt35 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback17(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt35 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt35++;
  if (__msg_callback_ret)
  {
    __tt16cnt35 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_FD1D_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22FD1D_PCB_Serial_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "FD1D", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_FD1D_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22FD1D_PCB_Serial_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "FD1D", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_FD1D_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xFD, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xFD;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x1D, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x1D;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt37 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback18", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt37 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt37);
        }
        if (__tt16cnt37 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback18(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt37 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt37++;
  if (__msg_callback_ret)
  {
    __tt16cnt37 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F11D_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x1D, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x1D;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt39 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback19", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt39 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt39);
        }
        if (__tt16cnt39 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback19(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt39 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt39++;
  if (__msg_callback_ret)
  {
    __tt16cnt39 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_FD38_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22FD38_Programmed_Assembly" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "FD38", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "RecordDataIdentifier", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, "FD38", elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'RecordDataIdentifier\'", "Bytes", __bArray, __bArrayCtr, "FD38");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Programmed_Assembly_0xFD38/Programmed_Assembly", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD38_Programmed_Assembly::`PROGRAMMED_ASSEMBLY, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Programmed_Assembly_0xFD38/Programmed_Assembly\'", "Bytes", __bArray, __bArrayCtr, "PROGRAMMED_ASSEMBLY");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_FD38_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22FD38_Programmed_Assembly" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Programmed_Assembly_0xFD38/Programmed_Assembly", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD38_Programmed_Assembly::`PROGRAMMED_ASSEMBLY, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Programmed_Assembly_0xFD38/Programmed_Assembly\'", "Bytes", __bArray, __bArrayCtr, "PROGRAMMED_ASSEMBLY");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_FD38_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xFD, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xFD;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x38, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x38;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt41 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback20", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt41 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt41);
        }
        if (__tt16cnt41 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback20(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt41 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt41++;
  if (__msg_callback_ret)
  {
    __tt16cnt41 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_FD13_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22FD13_Magna_Software_Version" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "FD13", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "RecordDataIdentifier", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, "FD13", elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'RecordDataIdentifier\'", "Bytes", __bArray, __bArrayCtr, "FD13");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Applicaion_SW_Year", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`App_Sw_Year, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Applicaion_SW_Year\'", "Bytes", __bArray, __bArrayCtr, "App_Sw_Year");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Applicaion_SW_Week", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`App_Sw_Week, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Applicaion_SW_Week\'", "Bytes", __bArray, __bArrayCtr, "App_Sw_Week");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Application_SW_Day_1", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`App_Sw_Day, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Application_SW_Day_1\'", "Bytes", __bArray, __bArrayCtr, "App_Sw_Day");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Applicaion_SW_Build_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`App_Sw_Build_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Applicaion_SW_Build_Number\'", "Bytes", __bArray, __bArrayCtr, "App_Sw_Build_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Year", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Bootloader_Sw_Year, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Year\'", "Bytes", __bArray, __bArrayCtr, "Bootloader_Sw_Year");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Week", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Bootloader_Sw_Week, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Week\'", "Bytes", __bArray, __bArrayCtr, "Bootloader_Sw_Week");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Day", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Bootloader_Sw_Day, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Day\'", "Bytes", __bArray, __bArrayCtr, "Bootloader_Sw_Day");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Build_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Bootloader_Sw_Build_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Build_Number\'", "Bytes", __bArray, __bArrayCtr, "Bootloader_Sw_Build_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Year", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`HSM_Year, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Year\'", "Bytes", __bArray, __bArrayCtr, "HSM_Year");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Week", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`HSM_Week, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Week\'", "Bytes", __bArray, __bArrayCtr, "HSM_Week");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Day", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`HSM_Day, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Day\'", "Bytes", __bArray, __bArrayCtr, "HSM_Day");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Build_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`HSM_Build_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Build_Number\'", "Bytes", __bArray, __bArrayCtr, "HSM_Build_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/USS_Firmware_version", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`USS_Firmware_Version_, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_Firmware_version\'", "Bytes", __bArray, __bArrayCtr, "USS_Firmware_Version_");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Year", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`USS_Sw_Year, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Year\'", "Bytes", __bArray, __bArrayCtr, "USS_Sw_Year");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Week", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`USS_Sw_Week, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Week\'", "Bytes", __bArray, __bArrayCtr, "USS_Sw_Week");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Day", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`USS_Sw_Day, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Day\'", "Bytes", __bArray, __bArrayCtr, "USS_Sw_Day");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Build_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`USS_Sw_Build_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Build_Number\'", "Bytes", __bArray, __bArrayCtr, "USS_Sw_Build_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/Planned_Release", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Planned_Release_, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/Planned_Release\'", "Bytes", __bArray, __bArrayCtr, "Planned_Release_");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/Reserved_for_6_more_blocks_to_accommodate", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Reserved_6_Bytes, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/Reserved_for_6_more_blocks_to_accommodate\'", "Bytes", __bArray, __bArrayCtr, "Reserved_6_Bytes");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_FD13_DID_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22FD13_Magna_Software_Version" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "FD13", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "RecordDataIdentifier", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, "FD13", elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'RecordDataIdentifier\'", "Bytes", __bArray, __bArrayCtr, "FD13");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Applicaion_SW_Year", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`App_Sw_Year, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Applicaion_SW_Year\'", "Bytes", __bArray, __bArrayCtr, "App_Sw_Year");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Applicaion_SW_Week", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`App_Sw_Week, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Applicaion_SW_Week\'", "Bytes", __bArray, __bArrayCtr, "App_Sw_Week");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Application_SW_Day_1", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`App_Sw_Day, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Application_SW_Day_1\'", "Bytes", __bArray, __bArrayCtr, "App_Sw_Day");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Applicaion_SW_Build_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`App_Sw_Build_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Applicaion_SW_Build_Number\'", "Bytes", __bArray, __bArrayCtr, "App_Sw_Build_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Year", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Bootloader_Sw_Year, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Year\'", "Bytes", __bArray, __bArrayCtr, "Bootloader_Sw_Year");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Week", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Bootloader_Sw_Week, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Week\'", "Bytes", __bArray, __bArrayCtr, "Bootloader_Sw_Week");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Day", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Bootloader_Sw_Day, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Day\'", "Bytes", __bArray, __bArrayCtr, "Bootloader_Sw_Day");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Build_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Bootloader_Sw_Build_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Build_Number\'", "Bytes", __bArray, __bArrayCtr, "Bootloader_Sw_Build_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Year", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`HSM_Year, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Year\'", "Bytes", __bArray, __bArrayCtr, "HSM_Year");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Week", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`HSM_Week, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Week\'", "Bytes", __bArray, __bArrayCtr, "HSM_Week");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Day", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`HSM_Day, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Day\'", "Bytes", __bArray, __bArrayCtr, "HSM_Day");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Build_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`HSM_Build_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Build_Number\'", "Bytes", __bArray, __bArrayCtr, "HSM_Build_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/USS_Firmware_version", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`USS_Firmware_Version_, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_Firmware_version\'", "Bytes", __bArray, __bArrayCtr, "USS_Firmware_Version_");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Year", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`USS_Sw_Year, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Year\'", "Bytes", __bArray, __bArrayCtr, "USS_Sw_Year");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Week", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`USS_Sw_Week, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Week\'", "Bytes", __bArray, __bArrayCtr, "USS_Sw_Week");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Day", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`USS_Sw_Day, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Day\'", "Bytes", __bArray, __bArrayCtr, "USS_Sw_Day");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Build_Number", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`USS_Sw_Build_Number, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Build_Number\'", "Bytes", __bArray, __bArrayCtr, "USS_Sw_Build_Number");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/Planned_Release", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Planned_Release_, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/Planned_Release\'", "Bytes", __bArray, __bArrayCtr, "Planned_Release_");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "Magna_Software_Version/Reserved_for_6_more_blocks_to_accommodate", __bDiagValueArray, __cDiagValueArray);
        sysParGetData(syspar::`FD13_Magna_SW_Version::`Reserved_6_Bytes, __bArray, __bArrayCtr);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/Reserved_for_6_more_blocks_to_accommodate\'", "Bytes", __bArray, __bArrayCtr, "Reserved_6_Bytes");
        __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_FD13_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xFD, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xFD;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x13, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x13;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt43 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback21", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt43 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt43);
        }
        if (__tt16cnt43 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback21(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt43 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt43++;
  if (__msg_callback_ret)
  {
    __tt16cnt43 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F18C_DID_with_Physical_Addressing()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_FD_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_FD_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464882 (0x98DAA0F2) on bus FDCAN2", "DIAGNOSTIC_REQUEST_FD_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xF1, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xF1;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x8C, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x8C;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt45 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485792 (0x98DAF2A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_FD_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_FD_PAM,  "__cbvee286jCallback22", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485792 (0x98DAF2A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_FD_PAM");
        if(__tt16cnt45 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt45);
        }
        if (__tt16cnt45 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback22(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt45 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt45++;
  if (__msg_callback_ret)
  {
    __tt16cnt45 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_F18C_DID_with_Functional_Addressing()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F18C_ECU_Serial_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F192_DID_with_Physical_Addressing()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F192_Supplier_ECU_Hardware_Part_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "F192", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F193_DID_with_Physical_Addressing()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F193_Supplier_ECU_Hardware_Version_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "F193", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_FD15_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22FD15_Magna_Production_HW_Number_Read" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "FD15", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_FD15_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xFD, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xFD;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x15, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x15;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt47 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback23", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt47 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt47);
        }
        if (__tt16cnt47 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback23(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt47 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt47++;
  if (__msg_callback_ret)
  {
    __tt16cnt47 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_FD17_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22FD17_Magna_Production_HW_Version_information_Read" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "FD17", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_FD17_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xFD, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xFD;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x17, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x17;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt49 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback24", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt49 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt49);
        }
        if (__tt16cnt49 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback24(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt49 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt49++;
  if (__msg_callback_ret)
  {
    __tt16cnt49 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_FD16_DID_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22FD16_Magna_Production_ICT_Data_Read" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "FD16", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_FD16_DID_with_Standard_Physical_Address()
{
  TestCommandBegin(__eRequestResponse, __cRequestResponse, "", "0");
  {
  
    long __res;
    int64 __timeout;
    __res = 0;
    __nInt64 = 1;
    __timeout = ((int64)syspar::`P2_Server) * 1000000;
    {
    
      long __testStepInitOk;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __output;
      message `FDCAN2::`DIAGNOSTIC_REQUEST_PAM __msgOrig;
      __output = __msgOrig;
      __testStepInitOk = 1;
      {
        int64 __dlc;
        __dlc = 4;
        if (__dlc >= 0 && __dlc <= (__output.EDL ? 15 : 8))
          __output.DLC = __dlc;
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Unable to set DLC=%I64d in message. Please check input parameter.", __dlc);
          __testStepInitOk = 0;
        }
      }
      if (__testStepInitOk)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564464881 (0x98DAA0F1) on bus FDCAN2", "DIAGNOSTIC_REQUEST_PAM");
        snprintf(__cArray2, elCount(__cArray2), "Send %s", __cArray);
        __ReportTableHead3Columns(__cArray2, "Byte", __cTOp, __cAssigned);
        __ReportByteIndex(__cEmpty, 0, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x3, "");
        
        if (0 >= 0 && 0 < 64)
        {
          __output.byte((word)0) = 0x3;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)0);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 1, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x22, "");
        
        if (1 >= 0 && 1 < 64)
        {
          __output.byte((word)1) = 0x22;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)1);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 2, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0xFD, "");
        
        if (2 >= 0 && 2 < 64)
        {
          __output.byte((word)2) = 0xFD;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)2);
          __testStepInitOk = 0;
        }
        __ReportByteIndex(__cEmpty, 3, __cArray);
        __ReportTableRow(0, __cArray, __cAOp, 0x16, "");
        
        if (3 >= 0 && 3 < 64)
        {
          __output.byte((word)3) = 0x16;
        
        }
        else
        {
          testStepErrorInTestSystem(0, __cEmpty, "Index out of range. Unable to set byte %I64d in message. Please check input parameter.", (int64)3);
          __testStepInitOk = 0;
        }
      
        __ReportTableEndTestStep("Req1");
      }
      if (__testStepInitOk)
      {
        output(__output);
      }
    }
    if (__timeout <= 0)
    {
      testStepErrorInTestSystem(0, "1", "Unable to wait for %.3f %s. Please check input parameter.", __timeout / ((float)1000000), "ms");
    }
    else
    {
      __tt16cnt51 = 0;
      snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
      __SetBusContext("FDCAN2", __eSaveCurrent);
       if(__BusContextOk())
         testJoinMessageEvent(`FDCAN2::`DIAGNOSTIC_RESPONSE_PAM,  "__cbvee286jCallback25", __cArray);
      __res = testWaitForAllJoinedEventsNS(__timeout);
      if (0 != __nInt64)
      {
        snprintf(__cArray, elCount(__cArray), "CAN message '%s' ID = 2564485536 (0x98DAF1A0) on bus FDCAN2", "DIAGNOSTIC_RESPONSE_PAM");
        if(__tt16cnt51 == -1)
        {
          snprintf(__cArray2, 2048, "Response of %s", __cArray);
        }
        else
        {
          snprintf(__cArray2, 2048, "Response of %s (received %d times)", __cArray, __tt16cnt51);
        }
        if (__tt16cnt51 == 0)
        {
          testStepFail(0, "Resp1", __cArray2);
        }
        else
        {
          testStepPass(2, "Resp1", __cArray2);
        }
        __ReportRequestResponseResult(__res, 0);
      }
      __ResetBusContext();
    }
  }
  TestCommandEnd();

}

dword __cbvee286jCallback25(message * __m)
{
  dword __msg_callback_ret;
  if (__tt16cnt51 == -1)
  {
    return 1;
  }
  __msg_callback_ret = 1;
  __tt16cnt51++;
  if (__msg_callback_ret)
  {
    __tt16cnt51 = -1;
    return 1;
  }
  return 0;
}

void Ttvee286j_Hard_Reset_with_Physical_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "HardReset_Reset" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_clear, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "ER_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'ER_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'ER_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "ResetType", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`ECU_Reset::`Hard_Reset, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'ResetType\'", "==", syspar::`ECU_Reset::`Hard_Reset, "Hard_Reset");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_Hard_Reset_with_Functional_Address()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "HardReset_Reset" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_functional, EnumSuppressPosResBit_clear, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "ER_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'ER_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'ER_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "ResetType", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`ECU_Reset::`Hard_Reset, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'ResetType\'", "==", syspar::`ECU_Reset::`Hard_Reset, "Hard_Reset");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j__19_02_Report_DTC_By_Status_Mask_Physical_Add()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "FaultMemory_ReadAllIdentified" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        byte __tcLocVar0[1] = { 0x02 };
      
        __bArrayCtr = elCount(__tcLocVar0);
        memcpy(__bArray, __tcLocVar0, __bArrayCtr);
        __res = __DiagSetParameter(__req, "ReportDtcByStatusMask", __bArray, __bArrayCtr);
        if(__res < 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'ReportDtcByStatusMask'");
          break;
        }
      }
      {
        byte __tcLocVar1[1] = { 0x7F };
      
        __bArrayCtr = elCount(__tcLocVar1);
        memcpy(__bArray, __tcLocVar1, __bArrayCtr);
        __res = __DiagSetParameter(__req, "DTCStatusMask", __bArray, __bArrayCtr);
        if(__res < 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'DTCStatusMask'");
          break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDI_RDTCBSM_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDI_RDTCBSM_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDI_RDTCBSM_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar2[1] = { 0x02 };
        byte __tcLocVar3[1] = { 0x7F };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "ReportDtcByStatusMask", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar2, elCount(__tcLocVar2)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'ReportDtcByStatusMask\'", "Bytes", __tcLocVar2, elCount(__tcLocVar2), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DtcAvailabilityMask", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar3, elCount(__tcLocVar3)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DtcAvailabilityMask\'", "Bytes", __tcLocVar3, elCount(__tcLocVar3), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j__14_Clear_Diag_Info_Physical_Add()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "FaultMemory_Clear" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "FFFFFF", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "GroupOfDtc", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'GroupOfDtc'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "GroupOfDtc");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'GroupOfDtc'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "CDI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'CDI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'CDI_PR'.");
        }
      }
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_TGW_Camera_Disp_Stat_4()
{
  TestCommandBegin(__eSet, __cSet, "", "0");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_14::`TGW_CAMERA_DISP_STAT.phys = 4;
      __ReportSignalSetLValue("CAN signal 'TGW_CAMERA_DISP_STAT'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_14::`TGW_CAMERA_DISP_STAT, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 4, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "2");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_14::`TGW_CAMERA_DISP_STAT, 4, "==") == 1;
      __ReportTableRow(0, "CAN signal 'TGW_CAMERA_DISP_STAT'", "==", 4, "");
      __ReportCell(`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_14::`TGW_CAMERA_DISP_STAT);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

}

void Ttvee286j_Sleep_Disable_CAN_Communication()
{
  TestCommandBegin(__eSet, __cSet, "", "0");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 1;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "2");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_14::`TGW_CAMERA_DISP_STAT.phys = 4;
      __ReportSignalSetLValue("CAN signal 'TGW_CAMERA_DISP_STAT'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_14::`TGW_CAMERA_DISP_STAT, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 4, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "4");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 0;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "Default");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "6");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`BCM_FD_10::`CmdIgnSts.phys = 0;
      __ReportSignalSetLValue("CAN signal 'CmdIgnSts'", `FDCAN2::dbNode::`BCM::`BCM_FD_10::`CmdIgnSts, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "8");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`IL::`Klemme15 = 0;
      __ReportTableRow(0, "System variable 'Klemme15'", __cAOp, 0, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "9");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "10");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`IL::`Klemme30 = 0;
      __ReportTableRow(0, "System variable 'Klemme30'", __cAOp, 0, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "11");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("stopTesterPresent", __eTestFct);
    CallInterfaceFunction("stopTesterPresent ()", __cEmpty, "12");
  }


  TestCommandBegin(__eWait, __cWait, "", "13");
  {
    __Wait("1", (20000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

}

void Ttvee286j_Wakeup_Enable_CAN()
{
  TestCommandBegin(__eSet, __cSet, "", "0");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`IL::`Klemme15 = 1;
      __ReportTableRow(0, "System variable 'Klemme15'", __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "1");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`IL::`Klemme30 = 1;
      __ReportTableRow(0, "System variable 'Klemme30'", __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (1010 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "3");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`BCM_FD_10::`CmdIgnSts.phys = 4;
      __ReportSignalSetLValue("CAN signal 'CmdIgnSts'", `FDCAN2::dbNode::`BCM::`BCM_FD_10::`CmdIgnSts, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 4, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("startTesterPresent", __eTestFct);
    CallInterfaceFunction("startTesterPresent ()", __cEmpty, "4");
  }


  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "6");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 2;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "R");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (150 * 1000000), 1000000, "");
  }
  TestCommandEnd();

}

void Ttvee286j_HardReset()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "HardReset_Reset" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_clear, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "ER_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'ER_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'ER_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "ResetType", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, syspar::`ECU_Reset::`Hard_Reset, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'ResetType\'", "==", syspar::`ECU_Reset::`Hard_Reset, "Hard_Reset");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_Default_Session_Start()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_Enable_CAN(int64 gear)
{
  TestCommandBegin(__eSet, __cSet, "", "0");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`BCM_FD_9::`DriverDoorSts.phys = 1;
      __ReportSignalSetLValue("CAN signal 'DriverDoorSts'", `FDCAN2::dbNode::`BCM::`BCM_FD_9::`DriverDoorSts, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 1, "Open");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "1");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`BCM_FD_9::`DriverDoorSts.phys = 0;
      __ReportSignalSetLValue("CAN signal 'DriverDoorSts'", `FDCAN2::dbNode::`BCM::`BCM_FD_9::`DriverDoorSts, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "Closed");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "2");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`IL::`Klemme15 = 1;
      __ReportTableRow(0, "System variable 'Klemme15'", __cAOp, 1, "");
    }
    {
      @sysvarInt::`IL::`Klemme30 = 1;
      __ReportTableRow(0, "System variable 'Klemme30'", __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (350 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "4");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`BCM_FD_10::`CmdIgnSts.phys = 4;
      __ReportSignalSetLValue("CAN signal 'CmdIgnSts'", `FDCAN2::dbNode::`BCM::`BCM_FD_10::`CmdIgnSts, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 4, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("startTesterPresent", __eTestFct);
    CallInterfaceFunction("startTesterPresent ()", __cEmpty, "5");
  }


  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (2010 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "7");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 1;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "8");
  {
    __Wait("1", (250 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "10");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "11");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 2;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "12");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

}

void Ttvee286j_TTFI_Enable_CAN()
{
  TestCommandBegin(__eSet, __cSet, "", "0");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`IL::`Klemme15 = 1;
      __ReportTableRow(0, "System variable 'Klemme15'", __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "1");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`IL::`Klemme30 = 1;
      __ReportTableRow(0, "System variable 'Klemme30'", __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (1010 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "3");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`BCM_FD_10::`CmdIgnSts.phys = 4;
      __ReportSignalSetLValue("CAN signal 'CmdIgnSts'", `FDCAN2::dbNode::`BCM::`BCM_FD_10::`CmdIgnSts, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 4, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("startTesterPresent", __eTestFct);
    CallInterfaceFunction("startTesterPresent ()", __cEmpty, "4");
  }


  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "6");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 2;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "R");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

}

void Ttvee286j_TTFI_Enable_CAN_Image()
{
  TestCommandBegin(__eSet, __cSet, "", "0");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`IL::`Klemme15 = 1;
      __ReportTableRow(0, "System variable 'Klemme15'", __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "1");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @sysvarInt::`IL::`Klemme30 = 1;
      __ReportTableRow(0, "System variable 'Klemme30'", __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (1010 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "3");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`BCM_FD_10::`CmdIgnSts.phys = 4;
      __ReportSignalSetLValue("CAN signal 'CmdIgnSts'", `FDCAN2::dbNode::`BCM::`BCM_FD_10::`CmdIgnSts, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 4, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("startTesterPresent", __eTestFct);
    CallInterfaceFunction("startTesterPresent ()", __cEmpty, "4");
  }


  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "6");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 2;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "R");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (1490 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Capture_And_Compare_G_V_S", __eTestFct);
    AddIFParameterInt(2);
    AddIFParameterInt(0);
    AddIFParameterInt(0);
    CallInterfaceFunction("Capture_And_Compare_G_V_S (gear=2, view=0, speed=0)", __cEmpty, "8");
  }


}

void Ttvee286j_Check_Session()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_Default_Session_Change()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_Check_Default_session_With_Application_Mode()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "RecordDataIdentifier", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, "F186", elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'RecordDataIdentifier\'", "Bytes", __bArray, __bArrayCtr, "F186");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j__General_Postcondition()
{
  TestCommandBegin(__eWait, __cWait, "", "0");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Check_DTC", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1");
  }


  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "3");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 1;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "5");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 2;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "View_2");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "7");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 1;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 1, "View_1");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "8");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "9");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 0;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "Default");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "10");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

}

void Ttvee286j__Diag_Send_Sleep_Disturb()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "4");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "6");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "8");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "9");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "10");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "11");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "12");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "13");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "14");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "15");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "16");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "17");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "18");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "19");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "20");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "21");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "22");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "23");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "24");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
