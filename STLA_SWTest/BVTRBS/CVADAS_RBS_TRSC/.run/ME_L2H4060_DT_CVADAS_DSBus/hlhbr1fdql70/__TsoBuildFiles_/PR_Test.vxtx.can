        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "311");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "312");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "313");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "314");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "315");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "316");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "317");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "318");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "319");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "320");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "321");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "322");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "323");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "324");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "325");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "326");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "327");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "328");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "329");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "330");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "331");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "332");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "333");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "334");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "335");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "336");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "337");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "338");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "339");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "340");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "341");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "342");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "343");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "344");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "345");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "346");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "347");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "348");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "349");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "350");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "351");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "352");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "353");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "354");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "355");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "356");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "357");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "358");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "359");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "360");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "361");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "362");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "363");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "364");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "365");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "366");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "367");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "368");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "369");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "370");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "371");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "372");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "373");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "374");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "375");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "376");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "377");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "378");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "379");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "380");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "381");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "382");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "383");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "384");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "385");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "386");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "387");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "388");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "389");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "390");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "391");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "392");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "393");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "394");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "395");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "396");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "397");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "398");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "399");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "400");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "401");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "402");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "403");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "404");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "405");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "406");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "407");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "408");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "409");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "410");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "411");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "412");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "413");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "414");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "415");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "416");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "417");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "418");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "419");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "420");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "421");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "422");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "423");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "424");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "425");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "426");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "427");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "428");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "429");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "430");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "431");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "432");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "433");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "434");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "435");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "436");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "437");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "438");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "439");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "440");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "441");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "442");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "443");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "444");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "445");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "446");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "447");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "448");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "449");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "450");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "451");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "452");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "453");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "454");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "455");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "456");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "457");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "458");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "459");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "460");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "461");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "462");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "463");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "464");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "465");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "466");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "467");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "468");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "469");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "470");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "471");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "472");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "473");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "474");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "475");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "476");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "477");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "478");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "479");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "480");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "481");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "482");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "483");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "484");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "485");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "486");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "487");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "488");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "489");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "490");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "491");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "492");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "493");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "494");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "495");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "496");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "497");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "498");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "499");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "500");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "501");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "502");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "503");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "504");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "505");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "506");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "507");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "508");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "509");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "510");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "511");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "512");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "513");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "514");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "515");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "516");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "517");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "518");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "519");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "520");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "521");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "522");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "523");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "524");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "525");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "526");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "527");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "528");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "529");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "530");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "531");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "532");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "533");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "534");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "535");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "536");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "537");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "538");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "539");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "540");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "541");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "542");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "543");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "544");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "545");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "546");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "547");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "548");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "549");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "550");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "551");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "552");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "553");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "554");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "555");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "556");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "557");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "558");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "559");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "560");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "561");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "562");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "563");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "564");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "565");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "566");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "567");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "568");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "569");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "570");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "571");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "572");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "573");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "574");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "575");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "576");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "577");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "578");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "579");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "580");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "581");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "582");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "583");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "584");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "585");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "586");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "587");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "588");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "589");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "590");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "591");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "592");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "593");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "594");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "595");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "596");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
