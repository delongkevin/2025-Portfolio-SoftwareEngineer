      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "597");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "598");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "599");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "600");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "601");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "602");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "603");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "604");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "605");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "606");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "607");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "608");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "609");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "610");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "611");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "612");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "613");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "614");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "615");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "616");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "617");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "618");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "619");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "620");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "621");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "622");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "623");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "624");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "625");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "626");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "627");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "628");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "629");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "630");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "631");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "632");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "633");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "634");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "635");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "636");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "637");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "638");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "639");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "640");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "641");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "642");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "643");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "644");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "645");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "646");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "647");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "648");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "649");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "650");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "651");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "652");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "653");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "654");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "655");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "656");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "657");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "658");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "659");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "660");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "661");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "662");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "663");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "664");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "665");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "666");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "667");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "668");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "669");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "670");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "671");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "672");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "673");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "674");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "675");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "676");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "677");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "678");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "679");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "680");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "681");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "682");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "683");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "684");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "685");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "686");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "687");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "688");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "689");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "690");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "691");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "692");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "693");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "694");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "695");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "696");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "697");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "698");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "699");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "700");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "701");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "702");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "703");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "704");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "705");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "706");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "707");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "708");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "709");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "710");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "711");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "712");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "713");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "714");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "715");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "716");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "717");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "718");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "719");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "720");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "721");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "722");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "723");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "724");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "725");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "726");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "727");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "728");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "729");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "730");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "731");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "732");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "733");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "734");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "735");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "736");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "737");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "738");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "739");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "740");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "741");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "742");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "743");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "744");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "745");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "746");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "747");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "748");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "749");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "750");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "751");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "752");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "753");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "754");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "755");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "756");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "757");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "758");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "759");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "760");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "761");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "762");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "763");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "764");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "765");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "766");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "767");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "768");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "769");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "770");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "771");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "772");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "773");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "774");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "775");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "776");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "777");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "778");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "779");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "780");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "781");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "782");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "783");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "784");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "785");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "786");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "787");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "788");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "789");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "790");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "791");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "792");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "793");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "794");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "795");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "796");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "797");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "798");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "799");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "800");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "801");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "802");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "803");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "804");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "805");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "806");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "807");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "808");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "809");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "810");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "811");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "812");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "813");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "814");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "815");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "816");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "817");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "818");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "819");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "820");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "821");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "822");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "823");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "824");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "825");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "826");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "827");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "828");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "829");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "830");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "831");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "832");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "833");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "834");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "835");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "836");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "837");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "838");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "839");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "840");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "841");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "842");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "843");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "844");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "845");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "846");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "847");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "848");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "849");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "850");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "851");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "852");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "853");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "854");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "855");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "856");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "857");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "858");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "859");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "860");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "861");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "862");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "863");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "864");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "865");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "866");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "867");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "868");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "869");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "870");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "871");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "872");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "873");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "874");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "875");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "876");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "877");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "878");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "879");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "880");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "881");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "882");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
