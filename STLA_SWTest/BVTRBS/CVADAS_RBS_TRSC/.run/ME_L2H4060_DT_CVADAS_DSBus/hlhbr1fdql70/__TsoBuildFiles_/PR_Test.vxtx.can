          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1169");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1170");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1171");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1172");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1173");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1174");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1175");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1176");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1177");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1178");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1179");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1180");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1181");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1182");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1183");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1184");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1185");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1186");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1187");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1188");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1189");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1190");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1191");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1192");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1193");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1194");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1195");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1196");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1197");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1198");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1199");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1200");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1201");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1202");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1203");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1204");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1205");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1206");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1207");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1208");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1209");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1210");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1211");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1212");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1213");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1214");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1215");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1216");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1217");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1218");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1219");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1220");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1221");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1222");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1223");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1224");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1225");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1226");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1227");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1228");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1229");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1230");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1231");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1232");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1233");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1234");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1235");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1236");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1237");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1238");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1239");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1240");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1241");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1242");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1243");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1244");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1245");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1246");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1247");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1248");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1249");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1250");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1251");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1252");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1253");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1254");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1255");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1256");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1257");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1258");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1259");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1260");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1261");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1262");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1263");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1264");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1265");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1266");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1267");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1268");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1269");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1270");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1271");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1272");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1273");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1274");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1275");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1276");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1277");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1278");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1279");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1280");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "1281");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1282");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F186_Active_Diagnostic_Session" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, (long)5000, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Active_Diagnostic_Session_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 01, "==") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Active_Diagnostic_Session_24\'", "==", 01, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "Running in Application", 2048) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'Bitfield/Bitfield._Active_Diagnostic_Session_of_ECU__ECU_Software_Mode_32\'", "==", "Running in Application", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j__Park_With_Image_Capture()
{
  TestCommandBegin(__eWait, __cWait, "", "0");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "1");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 1;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, 1, "==") == 1;
      __ReportTableRow(0, "CAN signal 'ShiftLeverPosition'", "==", 1, "");
      __ReportCell(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (2500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 1, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 1, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


}

void Ttvee286j__Reverse_With_Image_Capture()
{
  TestCommandBegin(__eWait, __cWait, "", "0");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "1");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 2;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, 2, "==") == 1;
      __ReportTableRow(0, "CAN signal 'ShiftLeverPosition'", "==", 2, "");
      __ReportCell(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 1, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 1, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


}

void Ttvee286j__Drive_With_Image_Capture()
{
  TestCommandBegin(__eWait, __cWait, "", "0");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "1");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 4;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 4, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "3");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, 4, "==") == 1;
      __ReportTableRow(0, "CAN signal 'ShiftLeverPosition'", "==", 4, "");
      __ReportCell(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "5");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 4, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 4, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


}

void Ttvee286j__General_Precondition()
{
  TestCommandBegin(__eWait, __cWait, "", "0");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "1");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_14::`TGW_CAMERA_DISP_STAT.phys = 4;
      __ReportSignalSetLValue("CAN signal 'TGW_CAMERA_DISP_STAT'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_14::`TGW_CAMERA_DISP_STAT, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 4, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "3");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`IPC_VEHICLE_SETUP::`SVC_Guidelines.phys = 1;
      __ReportSignalSetLValue("CAN signal 'SVC_Guidelines'", `FDCAN2::dbNode::`BCM::`IPC_VEHICLE_SETUP::`SVC_Guidelines, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "5");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`IPC_VEHICLE_SETUP::`Fwrd_Cam_Guidelines.phys = 1;
      __ReportSignalSetLValue("CAN signal 'Fwrd_Cam_Guidelines'", `FDCAN2::dbNode::`BCM::`IPC_VEHICLE_SETUP::`Fwrd_Cam_Guidelines, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "7");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN14::dbNode::`EPS::`EPS_FD_1::`LwsAngle.phys = 0;
      __ReportSignalSetLValue("CAN signal 'FDCAN14::EPS::EPS_FD_1::LwsAngle'", `FDCAN14::dbNode::`EPS::`EPS_FD_1::`LwsAngle, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "8");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Clear_DTC", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "9");
  }


  TestCommandBegin(__eWait, __cWait, "", "10");
  {
    __Wait("1", (150 * 1000000), 1000000, "");
  }
  TestCommandEnd();

}

void Ttvee286j__CaptureImage_py()
{
  TestCommandBegin(__eCAPLInline, __cCAPLInline, "", "0");
  {
    __civee286jCaplInline0();
  }
  TestCommandEnd();

}

void __civee286jCaplInline0 ()
{
  {
long response;
 
response = testWaitForSyscall("C:\\prjtools\\python\\ver_3.7.6_p7\\pythonw.exe CaptureImage.py", 1, 8000);

 
if (response != 1)
{
  testStepFail("","Unable to capture Image from CVADAS!");
}
else{
  testStepPass("","Image was Successfully Captured from CVADAS!");
}
  }
}

void Ttvee286j_Extended_Session_Change()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Extended_Diagnostic_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x03 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_DID_2023_Write_Valid_Proxi_Data_218Bytes_Phy()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_2E2023_PROXI_Data" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "2023", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
      {
        sysParGetData(syspar::`Vehicle_Configuration::`DID_2023_Write_Valid_Proxi_Data, __bArray, __bArrayCtr);
        __res = __DiagSetParameter(__req, "_Data_24", __bArray, __bArrayCtr);
        if(__res < 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter '_Data_24'");
          break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "WDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'WDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'WDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "RecordDataIdentifier", __bDiagValueArray, __cDiagValueArray);
      strncpy(__cArray, "2023", elCount(__cArray));  
        __bArrayCtr = __MapChar2ByteAtDiagCheck(__cArray, __bArray);
      __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __bArray, __bArrayCtr) == 0;
      __ReportTableRow(0, "Diagnostic parameter \'RecordDataIdentifier\'", "Bytes", __bArray, __bArrayCtr, "2023");
      __ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_General_Precondition()
{
  TestCommandBegin(__eWait, __cWait, "", "0");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Set_voltage", __eTestFct);
    AddIFParameterInt(syspar::`Power_Control::`RS_232_Port_Number);
    AddIFParameterDouble(syspar::`Power_Control::`Normal_Voltage);
    CallInterfaceFunction("Set_voltage (port=RS_232_Port_Number, volt=Normal_Voltage)", __cEmpty, "1");
  }


  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Reset_CAN", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "3");
  }


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (2500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "11");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        byte __tcLocVar0[1] = { 0x01 };
      
        __bArrayCtr = elCount(__tcLocVar0);
        memcpy(__bArray, __tcLocVar0, __bArrayCtr);
        __res = __DiagSetParameter(__req, "DiagSessionType", __bArray, __bArrayCtr);
        if(__res < 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'DiagSessionType'");
          break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar1[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar1, elCount(__tcLocVar1)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar1, elCount(__tcLocVar1), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "12");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

}

void Ttvee286j_General_Postconditions()
{
  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

}

void Ttvee286j_F181_DID_with_Physical_Address_PR()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F181_Application_Software_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Number_of_Application_SW_Logical_Blocks_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Number_of_Application_SW_Logical_Blocks_24\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Application_Software_Logical_Block_1_Version_Information__Year", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Application_Software_Logical_Block_1_Version_Information__Year\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Application_Software_Logical_Block_1_Version_Information__Week", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Application_Software_Logical_Block_1_Version_Information__Week\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Application_Software_Logical_Block_1_Version_Information__Patc", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Application_Software_Logical_Block_1_Version_Information__Patc\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F182_DID_with_Physical_Address_PR()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F182_Application_Data_Identification" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW_Year_32", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW_Year_32\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Week_40", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Week_40\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Patch_Level_48", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Patch_Level_48\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F180_DID_with_Physical_Address_PR()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F180_Boot_Software_Version_Information" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Number_of_Boot_Software_Logical_Blocks_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Number_of_Boot_Software_Logical_Blocks_24\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW_Year_32", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW_Year_32\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Week_40", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Week_40\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_SW__Patch_Level_48", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_SW__Patch_Level_48\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F132_DID_with_Physical_Address_PR()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F132_EBOM_ECU_Part_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "_EBOM_ECU_Part_Number_24", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "0", 2048) >= 0;
      __ReportTableRow(0, "Diagnostic parameter \'_EBOM_ECU_Part_Number_24\'", ">=", "0", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F112_DID_with_Physical_Addressing_PR()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F112_PTESLM_Hardware_Number" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __DiagGetParameter(__resp, "_Hardware_EBOM_Part_Number_24", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "0", 2048) >= 0;
      __ReportTableRow(0, "Diagnostic parameter \'_Hardware_EBOM_Part_Number_24\'", ">=", "0", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_F1A2_DID_with_Physical_Address_PR()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22F1A2_Vector_Delivery_ID" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Vector_Release_Version_Basic_Software_BSW_24", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Vector_Release_Version_Basic_Software_BSW_24\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Vector_License_Number_CBD_Number_48", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Vector_License_Number_CBD_Number_48\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Vector_Delivery_Number_80", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Vector_Delivery_Number_80\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Autosar_Revision_ASR_Major_Release_88", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Autosar_Revision_ASR_Major_Release_88\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "_Software_License_Package_SLP_96", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'_Software_License_Package_SLP_96\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_FD13_DID_with_Physical_Address_PR()
{
    
  TestCommandBegin(__eDiagService, __cDiagService, "", "0");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_22FD13_Magna_Software_Version" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
      {
        strncpy(__cDiagValueArray, "FD13", elCount(__cDiagValueArray));  
        __bDiagValueArrayCtr = __MapChar2ByteAtDiagSet(__cDiagValueArray, __bDiagValueArray);
        if (__bDiagValueArrayCtr >= 0)
        {
          __res = __DiagSetParameter(__req, "RecordDataIdentifier", __bDiagValueArray, __bDiagValueArrayCtr);
          if(__res < 0)
          {
            __bVerdict = __eVerdictFail;
            __DiagErrCodeTestStep(__res, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
            break;
          }
        }
        else
        {
      	__bVerdict = __eVerdictFail;
          snprintf(__cArray2, 2048, "SetParameter: illegal byte sequence: '%s' (parameter %s). Use hex tuples like '01 AF ...'", __cDiagValueArray, "RecordDataIdentifier");
          __DiagErrCodeTestStep(__bDiagValueArrayCtr, __cArray2);
          __DiagErrCodeTestStep(-1, "Cannot set diagnostic parameter 'RecordDataIdentifier'");
      	break;
        }
      }
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "RDBI_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'RDBI_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'RDBI_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "RecordDataIdentifier", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'RecordDataIdentifier\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Applicaion_SW_Year", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Applicaion_SW_Year\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Applicaion_SW_Week", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Applicaion_SW_Week\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Application_SW_Day_1", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Application_SW_Day_1\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Applicaion_SW_Build_Number", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Applicaion_SW_Build_Number\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Year", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Year\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Week", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Week\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Day", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Day\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_Bootloader_SW_Build_Number", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_Bootloader_SW_Build_Number\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Year", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Year\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Week", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Week\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Day", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Day\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Build_Number", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/CVADAS_DC_HSM_High_Security_Module_SW_Build_Number\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Magna_Software_Version/USS_Firmware_version", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "0", 2048) >= 0;
      __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_Firmware_version\'", ">=", "0", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Year", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Year\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Week", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Week\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Day", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Day\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        double __nDiagValue;
        __DiagGetParameter(__resp, "Magna_Software_Version/USS_SW_Build_Number", __nDiagValue);
        __csr = (CheckSignalMatch(__nDiagValue, 0, ">=") == 1);
        __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/USS_SW_Build_Number\'", ">=", 0, "");
        __ReportCell(__nDiagValue);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      {
        __DiagGetParameter(__resp, "Magna_Software_Version/Planned_Release", __bDiagValueArray, __cDiagValueArray);
      __csr = strncmp(__cDiagValueArray, "0", 2048) >= 0;
      __ReportTableRow(0, "Diagnostic parameter \'Magna_Software_Version/Planned_Release\'", ">=", "0", "");__ReportCell(__cDiagValueArray);
      __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

}

void Ttvee286j_Tet_TtInit()
{

}

void Ttvee286j_Tet_Tc0()
{
  CreateTTEIFFunction("Ttvee286j_Tc0", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673621_Defaults_Session_PR", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc0()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc0_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F180_DID_with_Physical_Address_PR", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "7dd2982f-fef7-4836-b2de-2e707de51074");
  }



}

void Ttvee286j_Tet_Tc0_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc1()
{
  CreateTTEIFFunction("Ttvee286j_Tc1", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673410_Defaults_Session_PR", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc1()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc1_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F181_DID_with_Physical_Address_PR", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0f83647e-81b9-42b5-aa2a-01420b0b8f82");
  }



}

void Ttvee286j_Tet_Tc1_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc2()
{
  CreateTTEIFFunction("Ttvee286j_Tc2", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673534_Standard_Physical_Address", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc2()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc2_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttvee286j_Default_Session_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "627cb293-726d-49b1-b2f7-7f87145feea3");
  }


  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_Extended_Session_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "58435b58-3d17-4ead-b77b-3e81b0124cf0");
  }


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_Standard_Physical_Address_Extended_Session", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1164fa28-24b1-4b88-89b6-88fe5bcc87f0");
  }


  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F182_DID_with_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "cb06dd89-9274-4c9f-9244-0e3e167f845e");
  }



}

void Ttvee286j_Tet_Tc2_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc3()
{
  CreateTTEIFFunction("Ttvee286j_Tc3", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673717_Defaults_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc3()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc3_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (40 * 1000000000), 1000000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "3");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_FD13_DID_with_Physical_Address_PR", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "c2a35bf3-2a25-474c-95f6-f1b5b01c7d0f");
  }


  TestCommandBegin(__eWait, __cWait, "", "8");
  {
    __Wait("1", (5 * 1000000000), 1000000000, "");
  }
  TestCommandEnd();


}

void Ttvee286j_Tet_Tc3_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc4()
{
  CreateTTEIFFunction("Ttvee286j_Tc4", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673596_Defaults_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc4()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc4_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  {
    CreateTTEIFFunction("Ttvee286j_F1A2_DID_with_Physical_Address_PR", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "65c760df-10c4-4159-9f87-156bd6069ef7");
  }



}

void Ttvee286j_Tet_Tc4_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc5()
{
  CreateTTEIFFunction("Ttvee286j_Tc5", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673528_Standard_Physical_Address", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc5()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc5_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttvee286j_Default_Session_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "627cb293-726d-49b1-b2f7-7f87145feea3");
  }


  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_Extended_Session_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "58435b58-3d17-4ead-b77b-3e81b0124cf0");
  }


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_Standard_Physical_Address_Extended_Session", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1164fa28-24b1-4b88-89b6-88fe5bcc87f0");
  }


  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_FD1D_DID_with_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "4caeb22b-33c1-451c-acad-b6e6ce15a022");
  }



}

void Ttvee286j_Tet_Tc5_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc6()
{
  CreateTTEIFFunction("Ttvee286j_Tc6", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673674_Defaults_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc6()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc6_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F10D_DID_with_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "fa229932-ef82-4a44-86dc-e022c2473f65");
  }



}

void Ttvee286j_Tet_Tc6_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc7()
{
  CreateTTEIFFunction("Ttvee286j_Tc7", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673470_Extended_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc7()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc7_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "4");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Extended_Diagnostic_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x03 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_ExtendedSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "56d9e7a7-9216-4d5f-b776-c5e862f155cb");
  }


  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F10D_DID_with_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "fa229932-ef82-4a44-86dc-e022c2473f65");
  }



}

void Ttvee286j_Tet_Tc7_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc8()
{
  CreateTTEIFFunction("Ttvee286j_Tc8", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673454_Defaults_Session_Physical", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc8()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc8_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F122_DID_with_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6f93660b-6512-4e07-84d9-4d430a77356f");
  }



}

void Ttvee286j_Tet_Tc8_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc9()
{
  CreateTTEIFFunction("Ttvee286j_Tc9", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673644_Defaults_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc9()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc9_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }



}

void Ttvee286j_Tet_Tc9_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc10()
{
  CreateTTEIFFunction("Ttvee286j_Tc10", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673517_Defaults_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc10()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc10_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F154_DID_with_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "69a5ea02-af07-4beb-8887-b2989586337a");
  }



}

void Ttvee286j_Tet_Tc10_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc11()
{
  CreateTTEIFFunction("Ttvee286j_Tc11", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673501_Extended_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc11()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc11_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "4");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Extended_Diagnostic_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x03 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_ExtendedSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "56d9e7a7-9216-4d5f-b776-c5e862f155cb");
  }


  TestCommandBegin(__eWait, __cWait, "", "8");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F154_DID_with_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "69a5ea02-af07-4beb-8887-b2989586337a");
  }



}

void Ttvee286j_Tet_Tc11_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc12()
{
  CreateTTEIFFunction("Ttvee286j_Tc12", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673656_Defaults_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc12()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc12_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F155_DID_with_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ae470781-01f8-4709-bed8-d79e10da78a1");
  }



}

void Ttvee286j_Tet_Tc12_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc13()
{
  CreateTTEIFFunction("Ttvee286j_Tc13", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673611_Defaults_Session_PR", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc13()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc13_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  {
    CreateTTEIFFunction("Ttvee286j_F132_DID_with_Physical_Address_PR", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "b608f7c5-ac77-4c86-b9bf-b636a6750188");
  }



}

void Ttvee286j_Tet_Tc13_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc14()
{
  CreateTTEIFFunction("Ttvee286j_Tc14", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673534_Standard_Physical_Address", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc14()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc14_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttvee286j_Default_Session_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "627cb293-726d-49b1-b2f7-7f87145feea3");
  }


  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_Extended_Session_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "58435b58-3d17-4ead-b77b-3e81b0124cf0");
  }


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_Standard_Physical_Address_Extended_Session", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1164fa28-24b1-4b88-89b6-88fe5bcc87f0");
  }


  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F187_DID_with_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "7ed78883-a682-4835-9c38-9165fe5890cc");
  }



}

void Ttvee286j_Tet_Tc14_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc15()
{
  CreateTTEIFFunction("Ttvee286j_Tc15", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673482_Defaults_Session_PR", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc15()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc15_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F122_DID_with_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6f93660b-6512-4e07-84d9-4d430a77356f");
  }



}

void Ttvee286j_Tet_Tc15_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc16()
{
  CreateTTEIFFunction("Ttvee286j_Tc16", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673534_Standard_Physical_Address", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc16()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc16_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttvee286j_Default_Session_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "627cb293-726d-49b1-b2f7-7f87145feea3");
  }


  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_Extended_Session_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "58435b58-3d17-4ead-b77b-3e81b0124cf0");
  }


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_Standard_Physical_Address_Extended_Session", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1164fa28-24b1-4b88-89b6-88fe5bcc87f0");
  }


  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_FD38_DID_with_Standard_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "b8623cc6-8450-4b5e-8182-86495aed05bd");
  }



}

void Ttvee286j_Tet_Tc16_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc17()
{
  CreateTTEIFFunction("Ttvee286j_Tc17", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673689_Defaults_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc17()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc17_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F18C_DID_with_Physical_Addressing", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "7486d1d1-c748-460d-8de2-86a63e092c0d");
  }



}

void Ttvee286j_Tet_Tc17_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc18()
{
  CreateTTEIFFunction("Ttvee286j_Tc18", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673516_Extended_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc18()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc18_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "3");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Extended_Diagnostic_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x03 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_ExtendedSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "56d9e7a7-9216-4d5f-b776-c5e862f155cb");
  }



}

void Ttvee286j_Tet_Tc18_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc19()
{
  CreateTTEIFFunction("Ttvee286j_Tc19", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673521_Default_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc19()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc19_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }



}

void Ttvee286j_Tet_Tc19_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc20()
{
  CreateTTEIFFunction("Ttvee286j_Tc20", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673513_Hard_Reset", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc20()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc20_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

  {
    CreateCaplIFFunction("startTesterPresent", __eTestFct);
    CallInterfaceFunction("startTesterPresent ()", __cEmpty, "2");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "", "3");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "4");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Extended_Diagnostic_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x03 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_ExtendedSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "56d9e7a7-9216-4d5f-b776-c5e862f155cb");
  }


  {
    CreateTTEIFFunction("Ttvee286j_Hard_Reset_with_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "89dfe39a-bb1d-4a37-afea-34e7a683daba");
  }


  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (15 * 1000000000), 1000000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_F186_DID_with_PhysicalAdd_DefaultSession", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "f479ea65-8c8c-4093-b3d8-2a8374608569");
  }


  TestCommandBegin(__eWait, __cWait, "", "9");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();


}

void Ttvee286j_Tet_Tc20_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc21()
{
  CreateTTEIFFunction("Ttvee286j_Tc21", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673515_Extended_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc21()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc21_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "1");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Extended_Diagnostic_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x03 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__14_Clear_Diag_Info_Physical_Add", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "40838b5f-11dc-4109-b8cf-d5b7edc39c35");
  }


  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__19_02_Report_DTC_By_Status_Mask_Physical_Add", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "80b4f264-ae49-4a22-969d-f9650a5d9f64");
  }



}

void Ttvee286j_Tet_Tc21_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc22()
{
  CreateTTEIFFunction("Ttvee286j_Tc22", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673510_Hard_Reset", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc22()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc22_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

  {
    CreateCaplIFFunction("startTesterPresent", __eTestFct);
    CallInterfaceFunction("startTesterPresent ()", __cEmpty, "2");
  }


    
  TestCommandBegin(__eDiagService, __cDiagService, "", "3");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "4");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Extended_Diagnostic_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x03 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j_Hard_Reset_with_Physical_Address", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "89dfe39a-bb1d-4a37-afea-34e7a683daba");
  }


  TestCommandBegin(__eWait, __cWait, "", "6");
  {
    __Wait("1", (15 * 1000000000), 1000000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__14_Clear_Diag_Info_Physical_Add", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "40838b5f-11dc-4109-b8cf-d5b7edc39c35");
  }


  TestCommandBegin(__eWait, __cWait, "", "8");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__19_02_Report_DTC_By_Status_Mask_Physical_Add", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "80b4f264-ae49-4a22-969d-f9650a5d9f64");
  }



}

void Ttvee286j_Tet_Tc22_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc23()
{
  CreateTTEIFFunction("Ttvee286j_Tc23", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673507_Power_Cycle", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc23()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc23_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

  {
    CreateCaplIFFunction("Power_Supply_OFF", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "1");
  }


  TestCommandBegin(__eWait, __cWait, "", "2");
  {
    __Wait("1", (2000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Power_Supply_ON", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "3");
  }


  TestCommandBegin(__eWait, __cWait, "", "4");
  {
    __Wait("1", (3500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "20");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @`MEnv_Default_SET_BOL_1 = 0;
      __ReportTableRow(0, "Environment variable 'MEnv_Default_SET_BOL_1'", __cAOp, 0, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "21");
  {
    __Wait("1", (200 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "22");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      @`MEnv_Default_SET_BOL_1 = 1;
      __ReportTableRow(0, "Environment variable 'MEnv_Default_SET_BOL_1'", __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "23");
  {
    __Wait("1", (3100 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("startTesterPresent", __eTestFct);
    CallInterfaceFunction("startTesterPresent ()", __cEmpty, "24");
  }


  TestCommandBegin(__eWait, __cWait, "", "25");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "26");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Extended_Diagnostic_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x03 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("startTesterPresent", __eTestFct);
    CallInterfaceFunction("startTesterPresent ()", __cEmpty, "27");
  }


  TestCommandBegin(__eWait, __cWait, "", "28");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "29");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "_221004_Battery_Voltage" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
    }
    while(0);
  
  
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "30");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__14_Clear_Diag_Info_Physical_Add", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "40838b5f-11dc-4109-b8cf-d5b7edc39c35");
  }


  TestCommandBegin(__eWait, __cWait, "", "32");
  {
    __Wait("1", (1000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__19_02_Report_DTC_By_Status_Mask_Physical_Add", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "80b4f264-ae49-4a22-969d-f9650a5d9f64");
  }



}

void Ttvee286j_Tet_Tc23_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc24()
{
  CreateTTEIFFunction("Ttvee286j_Tc24", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("TC_ID_21673533_Extended_Session", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc24()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc24_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("General_Precondition", __eFct, __eGlobal);
      CallInterfaceFunction(__cEmpty, __cEmpty, __cEmpty);
    }


  }
  TestPreparationEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "2");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Default_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x01 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();

    
  TestCommandBegin(__eDiagService, __cDiagService, "", "3");
  {
    long __res, __paramLen, __bytePos;
    DiagResponse * __resp;
    DiagRequest "Extended_Diagnostic_Session_Start" __req;
  
    __bVerdict = __eVerdictPass;
  
    do {
      if(!__DiagSetTarget("CVADAS_0001_00000000_000"))
        break;
  
      TestReportResetDiagObjectList();
      DiagSetReportDetailLevel(EnumServiceDetails_onfail);
      // Request aspect
      {
  
        if (0 >= __DiagSendReqAndWaitForResp(__req, -1, -1, -1, -1, -1, EnumResult_pos, EnumServiceDetails_onfail, EnumSendingMode_physical, EnumSuppressPosResBit_asconfigured, EnumVerdictOnInvalidValues_fail))
          break;
      }
  
      __res = __req.GetLastResponse(__resp);
      __res = __DiagErrCodeTestStep(__res, "Can't retrieve last response for request! No check possible.") < 0;
      if(__res)
      {
  	  __bVerdict = __eVerdictFail;
        break;
      }
      {
        __res = DiagInterpretAs(__resp, "DSC_PR");
        if(__res != 0)
        {
          __bVerdict = __eVerdictFail;
          __DiagErrCodeTestStep(__res, "Can't interpret response as diagnostic primitive 'DSC_PR'.");
          break;
        }
        else
        {
          TestStepPass( "Received primitive can be interpreted as diagnostic primitive 'DSC_PR'.");
        }
      }
    }
    while(0);
  
  
    // Response, check & read aspect
    {
        byte __tcLocVar0[1] = { 0x03 };
  
      __res = 1;
      __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
      {
        __bDiagValueArrayCtr = __DiagGetParameter(__resp, "DiagSessionType", __bDiagValueArray, __cDiagValueArray);
        __csr = __CompareBytes(__bDiagValueArray, __bDiagValueArrayCtr, __tcLocVar0, elCount(__tcLocVar0)) == 0;
        __ReportTableRow(0, "Diagnostic parameter \'DiagSessionType\'", "Bytes", __tcLocVar0, elCount(__tcLocVar0), "");__ReportCell(__bDiagValueArray, __bDiagValueArrayCtr);
        __ReportCellResult(__csr, __ePassFail);
        __res = __res && __csr;
      
      }
      __ReportTableEndVerdict(__cEvaluateResponse, __res);
  	__bVerdict = __bVerdict && __res;
    }
    if (__bVerdict == __eVerdictFail)
      TestReportWriteDiagObjectList();
  }
  TestCommandEnd();


}

void Ttvee286j_Tet_Tc24_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j_General_Postconditions", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "34bae385-7cb4-43dd-9d31-0569817a5ab1");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc25()
{
  CreateTTEIFFunction("Ttvee286j_Tc25", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("HMI_View_Switch_Park_With_No_FFCV_Jenkins", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc25()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc25_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j__General_Precondition", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "bcd305e4-1786-4357-a9fb-721aa1b14afe");
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eWait, __cWait, "", "1");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "2");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 1;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 1, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, 1, "==") == 1;
      __ReportTableRow(0, "CAN signal 'ShiftLeverPosition'", "==", 1, "");
      __ReportCell(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "6");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 2;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "View_2");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 5, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 5, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "9");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "13");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "21");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 6;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 6, "View_6");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "22");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "23");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 6, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 6, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "24");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "27");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "28");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 7;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 7, "View_7");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "29");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "30");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 7, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 7, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "31");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "34");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "35");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 8;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 8, "View_8");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "36");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "37");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 10, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 10, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "38");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "41");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "42");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 9;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 9, "View_9");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "43");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "44");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 11, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 11, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "45");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "48");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "49");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 11;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 11, "View_11");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "50");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "51");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 4, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 4, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "52");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "55");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "56");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 12;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 12, "View_12");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "57");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "58");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 1, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 1, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "59");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "62");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "63");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 13;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 13, "View_13");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "64");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "65");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 3, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 3, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "66");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "69");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "70");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 14;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 14, "View_14");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "71");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "72");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 2, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 2, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "73");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "76");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "77");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 2;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "View_2");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "78");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 0;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "Default");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "79");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Check_DTC", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "80");
  }


  TestCommandBegin(__eWait, __cWait, "", "81");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();


}

void Ttvee286j_Tet_Tc25_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j__General_Postcondition", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "63f5a7a4-fa1d-4e71-b857-91cbcb24353d");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc26()
{
  CreateTTEIFFunction("Ttvee286j_Tc26", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("HMI_View_Switch_Reverse_With_No_FFCV_Jenkins", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc26()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc26_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j__General_Precondition", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "bcd305e4-1786-4357-a9fb-721aa1b14afe");
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eWait, __cWait, "", "1");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "2");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 2;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, 2, "==") == 1;
      __ReportTableRow(0, "CAN signal 'ShiftLeverPosition'", "==", 2, "");
      __ReportCell(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "6");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 2;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "View_2");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 5, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 5, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "9");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "12");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "21");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 6;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 6, "View_6");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "22");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "23");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 6, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 6, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "24");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "28");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "29");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 7;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 7, "View_7");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "30");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "31");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 7, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 7, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "32");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "36");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "37");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 8;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 8, "View_8");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "38");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "39");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 10, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 10, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "40");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "44");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "45");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 9;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 9, "View_9");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "46");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "47");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 11, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 11, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "48");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "52");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "53");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 11;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 11, "View_11");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "54");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "55");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 4, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 4, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "56");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "60");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "61");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 12;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 12, "View_12");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "62");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "63");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 1, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 1, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "64");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "68");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "69");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 13;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 13, "View_13");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "70");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "71");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 3, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 3, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "72");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "76");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "77");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 14;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 14, "View_14");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "78");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "79");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 2, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 2, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "80");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "84");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "85");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 2;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "View_2");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "86");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 0;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "Default");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "87");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Check_DTC", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "88");
  }


  TestCommandBegin(__eWait, __cWait, "", "89");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();


}

void Ttvee286j_Tet_Tc26_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j__General_Postcondition", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "63f5a7a4-fa1d-4e71-b857-91cbcb24353d");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc27()
{
  CreateTTEIFFunction("Ttvee286j_Tc27", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("HMI_View_Switch_Drive_With_No_FFCV_Jenkins", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc27()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc27_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j__General_Precondition", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "bcd305e4-1786-4357-a9fb-721aa1b14afe");
    }


  }
  TestPreparationEnd();

  TestCommandBegin(__eWait, __cWait, "", "1");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "2");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition.phys = 4;
      __ReportSignalSetLValue("CAN signal 'ShiftLeverPosition'", `FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 4, "");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "3");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "4");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition, 4, "==") == 1;
      __ReportTableRow(0, "CAN signal 'ShiftLeverPosition'", "==", 4, "");
      __ReportCell(`FDCAN2::dbNode::`BCM::`TRANSM_FD_4::`ShiftLeverPosition);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "5");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "6");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 2;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "View_2");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "7");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "8");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 5, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 5, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "9");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "13");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "22");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 6;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 6, "View_6");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "23");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "24");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 6, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 6, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "25");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "29");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "30");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 7;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 7, "View_7");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "31");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "32");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 7, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 7, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "33");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "37");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "38");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 8;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 8, "View_8");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "39");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "40");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 10, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 10, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "41");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "45");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "46");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 9;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 9, "View_9");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "47");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "48");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 11, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 11, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "49");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "53");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "54");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 11;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 11, "View_11");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "55");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "56");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 4, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 4, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "57");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "61");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "62");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 12;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 12, "View_12");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "63");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "64");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 1, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 1, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "65");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "69");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "70");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 13;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 13, "View_13");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "71");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "72");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 3, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 3, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "73");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "77");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "78");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 14;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 14, "View_14");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "79");
  {
    __Wait("1", (3000 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eCheck, __cCheck, "", "80");
  {
    __bVerdict = __eVerdictPass;
    __ReportTableHead5Columns(__cCheckCaption, __cTSym, __cTOp, __cRefVal, __cActual, __cRes);
    {
      __csr = CheckSignalMatch(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2, 2, "==") == 1;
      __ReportTableRow(0, "CAN signal 'DisplayView2'", "==", 2, "");
      __ReportCell(`FDCAN2::dbNode::`CVADAS::`CVPAM_FD_Info::`DisplayView2);
      __ReportCellResult(__csr, __ePassFail);
      __bVerdict = __bVerdict && __csr;
    }
    __ReportTableEndVerdict("1", __bVerdict);
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "81");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__CaptureImage_py", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "92488b41-8ece-42b6-b09a-2babc3861737");
  }


  TestCommandBegin(__eWait, __cWait, "", "85");
  {
    __Wait("1", (50 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "86");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 2;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 2, "View_2");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eSet, __cSet, "", "87");
  {
  
    __ReportTableHead3Columns(__cSetCaption , __cTSym, __cTOp, __cAssigned); 
    {
      $`FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2.phys = 0;
      __ReportSignalSetLValue("CAN signal 'CameraDisplaySts2'", `FDCAN2::dbNode::`SGW::`TELEMATIC_FD_5::`CameraDisplaySts2, __cArray);
      __ReportTableRow(0, __cArray, __cAOp, 0, "Default");
    }
    __ReportTableEndTestStep("1");
  }
  TestCommandEnd();

  TestCommandBegin(__eWait, __cWait, "", "88");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Check_DTC", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "89");
  }


  TestCommandBegin(__eWait, __cWait, "", "90");
  {
    __Wait("1", (1500 * 1000000), 1000000, "");
  }
  TestCommandEnd();


}

void Ttvee286j_Tet_Tc27_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j__General_Postcondition", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "63f5a7a4-fa1d-4e71-b857-91cbcb24353d");
    }


  }
  TestCompletionEnd();
}

void Ttvee286j_Tet_Tc28()
{
  CreateTTEIFFunction("Ttvee286j_Tc28", __eTcDef, __eLocal);  
  AddIFParameterTestCaseAttribute("TC_ID", "");
  AddIFParameterTestCaseAttribute("Test Case ID", "");
  CallInterfaceFunction("Gear_Change_With_Image_Capture_Jenkins", __cEmpty , __cEmpty );
}
testcase Ttvee286j_Tc28()
{	
  SetBreakOnFail(0);

  CreateTTEIFFunction("Ttvee286j_Tet_Tc28_Completion", __eFct, __eLocal);
  
  AddIFAsCleanUpFunction();

  TestPreparationBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j__General_Precondition", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "bcd305e4-1786-4357-a9fb-721aa1b14afe");
    }


  }
  TestPreparationEnd();

  {
    CreateTTEIFFunction("Ttvee286j__Park_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ca33447b-caa7-40fe-99fc-15725515eab7");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Reverse_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6a8b12e2-cc8e-4e0b-8a01-3376eb39cfda");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Drive_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0848399f-46f1-46e3-8717-85b9638d8a7a");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Reverse_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6a8b12e2-cc8e-4e0b-8a01-3376eb39cfda");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Park_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ca33447b-caa7-40fe-99fc-15725515eab7");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Reverse_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6a8b12e2-cc8e-4e0b-8a01-3376eb39cfda");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Drive_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0848399f-46f1-46e3-8717-85b9638d8a7a");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Reverse_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6a8b12e2-cc8e-4e0b-8a01-3376eb39cfda");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Drive_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0848399f-46f1-46e3-8717-85b9638d8a7a");
  }


  TestCommandBegin(__eWait, __cWait, "", "10");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateCaplIFFunction("Check_DTC", __eFct);
    CallInterfaceFunction(__cEmpty, __cEmpty, "11");
  }


  TestCommandBegin(__eWait, __cWait, "", "12");
  {
    __Wait("1", (500 * 1000000), 1000000, "");
  }
  TestCommandEnd();

  {
    CreateTTEIFFunction("Ttvee286j__Reverse_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6a8b12e2-cc8e-4e0b-8a01-3376eb39cfda");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Park_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ca33447b-caa7-40fe-99fc-15725515eab7");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Reverse_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6a8b12e2-cc8e-4e0b-8a01-3376eb39cfda");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Drive_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0848399f-46f1-46e3-8717-85b9638d8a7a");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Reverse_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6a8b12e2-cc8e-4e0b-8a01-3376eb39cfda");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Park_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "ca33447b-caa7-40fe-99fc-15725515eab7");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Reverse_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6a8b12e2-cc8e-4e0b-8a01-3376eb39cfda");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Drive_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0848399f-46f1-46e3-8717-85b9638d8a7a");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Reverse_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6a8b12e2-cc8e-4e0b-8a01-3376eb39cfda");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Drive_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0848399f-46f1-46e3-8717-85b9638d8a7a");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Reverse_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "6a8b12e2-cc8e-4e0b-8a01-3376eb39cfda");
  }


  {
    CreateTTEIFFunction("Ttvee286j__Drive_With_Image_Capture", __eFct, __eLocal);
    CallInterfaceFunction(__cEmpty, __cEmpty, "0848399f-46f1-46e3-8717-85b9638d8a7a");
  }



}

void Ttvee286j_Tet_Tc28_Completion()
{  
  TestCompletionBegin();
  {
    {
      CreateTTEIFFunction("Ttvee286j__General_Postcondition", __eFct, __eLocal);
      CallInterfaceFunction(__cEmpty, __cEmpty, "63f5a7a4-fa1d-4e71-b857-91cbcb24353d");
    }


  }
  TestCompletionEnd();
}

